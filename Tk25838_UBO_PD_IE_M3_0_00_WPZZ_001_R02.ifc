Properties of the parts of a building model (IFC4), part 3 of 23

# IfcBuildingElementProxy: 04 - Unel doppia:EFX_I_UnelDoppia (150)
Name (04 - Unel doppia:EFX_I_UnelDoppia:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
8977233 | L00 - Piano Terra Piazza ELETTRICO | 3871 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977343 | L00 - Piano Terra Piazza ELETTRICO | 3872 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977364 | L00 - Piano Terra Piazza ELETTRICO | 3873 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977414 | L00 - Piano Terra Piazza ELETTRICO | 3874 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977506 | L00 - Piano Terra Piazza ELETTRICO | 3875 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977614 | L00 - Piano Terra Piazza ELETTRICO | 3876 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977832 | L00 - Piano Terra Piazza ELETTRICO | 3877 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977842 | L00 - Piano Terra Piazza ELETTRICO | 3878 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8977971 | L00 - Piano Terra Piazza ELETTRICO | 3879 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8978142 | L00 - Piano Terra Piazza ELETTRICO | 3880 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8978245 | L00 - Piano Terra Piazza ELETTRICO | 3881 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8980061 | L00 - Piano Terra Piazza ELETTRICO | 3886 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8980091 | L00 - Piano Terra Piazza ELETTRICO | 3887 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8980309 | L00 - Piano Terra Piazza ELETTRICO | 3888 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8980761 | L00 - Piano Terra Piazza ELETTRICO | 3889 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8980774 | L00 - Piano Terra Piazza ELETTRICO | 3890 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8983758 | L00 - Piano Terra Piazza ELETTRICO | 3931 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8983771 | L00 - Piano Terra Piazza ELETTRICO | 3932 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8991888 | L02 - Piano Secondo ELETTRICO | 4068 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8991910 | L02 - Piano Secondo ELETTRICO | 4069 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992454 | L02 - Piano Secondo ELETTRICO | 4070 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992511 | L02 - Piano Secondo ELETTRICO | 4071 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992594 | L02 - Piano Secondo ELETTRICO | 4072 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992637 | L02 - Piano Secondo ELETTRICO | 4073 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992711 | L02 - Piano Secondo ELETTRICO | 4074 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992808 | L02 - Piano Secondo ELETTRICO | 4075 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992906 | L02 - Piano Secondo ELETTRICO | 4076 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8992968 | L02 - Piano Secondo ELETTRICO | 4077 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8993046 | L02 - Piano Secondo ELETTRICO | 4078 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8993086 | L02 - Piano Secondo ELETTRICO | 4079 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8993267 | L02 - Piano Secondo ELETTRICO | 4080 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8993779 | L02 - Piano Secondo ELETTRICO | 4081 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8993848 | L02 - Piano Secondo ELETTRICO | 4082 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8993930 | L02 - Piano Secondo ELETTRICO | 4083 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994210 | L02 - Piano Secondo ELETTRICO | 4084 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994255 | L02 - Piano Secondo ELETTRICO | 4085 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994328 | L02 - Piano Secondo ELETTRICO | 4086 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994520 | L02 - Piano Secondo ELETTRICO | 4087 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994716 | L02 - Piano Secondo ELETTRICO | 4088 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994779 | L02 - Piano Secondo ELETTRICO | 4089 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994863 | L02 - Piano Secondo ELETTRICO | 4090 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8994991 | L02 - Piano Secondo ELETTRICO | 4091 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8995075 | L02 - Piano Secondo ELETTRICO | 4092 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8995139 | L02 - Piano Secondo ELETTRICO | 4093 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.343
8995255 | L02 - Piano Secondo ELETTRICO | 4094 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8995459 | L02 - Piano Secondo ELETTRICO | 4095 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8995804 | L02 - Piano Secondo ELETTRICO | 4096 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8995848 | L02 - Piano Secondo ELETTRICO | 4097 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8995949 | L02 - Piano Secondo ELETTRICO | 4098 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996035 | L02 - Piano Secondo ELETTRICO | 4099 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996073 | L02 - Piano Secondo ELETTRICO | 4100 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996232 | L02 - Piano Secondo ELETTRICO | 4101 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996264 | L02 - Piano Secondo ELETTRICO | 4102 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996342 | L02 - Piano Secondo ELETTRICO | 4103 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996443 | L02 - Piano Secondo ELETTRICO | 4104 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996497 | L02 - Piano Secondo ELETTRICO | 4105 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996572 | L02 - Piano Secondo ELETTRICO | 4106 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996694 | L02 - Piano Secondo ELETTRICO | 4107 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996775 | L02 - Piano Secondo ELETTRICO | 4108 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996854 | L02 - Piano Secondo ELETTRICO | 4109 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8996903 | L02 - Piano Secondo ELETTRICO | 4110 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8997101 | L02 - Piano Secondo ELETTRICO | 4111 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8997219 | L02 - Piano Secondo ELETTRICO | 4112 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8997543 | L02 - Piano Secondo ELETTRICO | 4113 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8997553 | L02 - Piano Secondo ELETTRICO | 4114 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8998011 | L02 - Piano Secondo ELETTRICO | 4119 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8998026 | L02 - Piano Secondo ELETTRICO | 4120 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9036585 | L00 - Piano Terra Piazza ELETTRICO | 4147 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9059070 | L02 - Piano Secondo ELETTRICO | 4156 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9059081 | L02 - Piano Secondo ELETTRICO | 4157 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9059193 | L02 - Piano Secondo ELETTRICO | 4158 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9059336 | L02 - Piano Secondo ELETTRICO | 4159 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9059581 | L02 - Piano Secondo ELETTRICO | 4160 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9059872 | L02 - Piano Secondo ELETTRICO | 4161 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9059892 | L02 - Piano Secondo ELETTRICO | 4162 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9060365 | L02 - Piano Secondo ELETTRICO | 4163 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9060627 | L02 - Piano Secondo ELETTRICO | 4164 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
9060759 | L02 - Piano Secondo ELETTRICO | 4165 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10292283 | B01 - Piano Interrato ELETTRICO | 4554 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2 | Dati identità - Commenti: Aula magna
10292298 | B01 - Piano Interrato ELETTRICO | 4555 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10292545 | L00 - Piano Terra Piazza ELETTRICO | 4556 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10292564 | L00 - Piano Terra Piazza ELETTRICO | 4557 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0365 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10292760 | L00 - Piano Terra Piazza ELETTRICO | 4558 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10292797 | L00 - Piano Terra Piazza ELETTRICO | 4559 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10295545 | L00 - Piano Terra Piazza ELETTRICO | 4573 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10295771 | L00 - Piano Terra Piazza ELETTRICO | 4575 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0530008 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10296719 | L00 - Piano Terra Piazza ELETTRICO | 4577 | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.0000322366 | <non associato> | 0.3
10296739 | L00 - Piano Terra Piazza ELETTRICO | 4578 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0530008 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10296888 | L00 - Piano Terra Piazza ELETTRICO | 4579 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10296902 | L00 - Piano Terra Piazza ELETTRICO | 4580 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10297289 | L00 - Piano Terra Piazza ELETTRICO | 4583 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10297307 | L00 - Piano Terra Piazza ELETTRICO | 4584 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10297951 | L00 - Piano Terra Piazza ELETTRICO | 4586 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10297973 | L00 - Piano Terra Piazza ELETTRICO | 4587 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
10297998 | L00 - Piano Terra Piazza ELETTRICO | 4588 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10299002 | L00 - Piano Terra Piazza ELETTRICO | 4596 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10299731 | L00 - Piano Terra Piazza ELETTRICO | 4601 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
10299740 | L00 - Piano Terra Piazza ELETTRICO | 4602 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.393
10300227 | L00 - Piano Terra Piazza ELETTRICO | 4606 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10300243 | L00 - Piano Terra Piazza ELETTRICO | 4607 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10300749 | L00 - Piano Terra Piazza ELETTRICO | 4609 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10300769 | L00 - Piano Terra Piazza ELETTRICO | 4610 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10300993 | L00 - Piano Terra Piazza ELETTRICO | 4611 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10301015 | L00 - Piano Terra Piazza ELETTRICO | 4612 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10301268 | L00 - Piano Terra Piazza ELETTRICO | 4613 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10301523 | L00 - Piano Terra Piazza ELETTRICO | 4614 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10302023 | L00 - Piano Terra Piazza ELETTRICO | 4617 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10303733 | L00 - Piano Terra Piazza ELETTRICO | 4631 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10303746 | L00 - Piano Terra Piazza ELETTRICO | 4632 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10304328 | L00 - Piano Terra Piazza ELETTRICO | 4638 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10304351 | L00 - Piano Terra Piazza ELETTRICO | 4639 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10304452 | L00 - Piano Terra Piazza ELETTRICO | 4640 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10304617 | L00 - Piano Terra Piazza ELETTRICO | 4641 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10305030 | L00 - Piano Terra Piazza ELETTRICO | 4643 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.393
10305070 | L00 - Piano Terra Piazza ELETTRICO | 4644 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10305092 | L00 - Piano Terra Piazza ELETTRICO | 4645 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10309239 | B01 - Piano Interrato ELETTRICO | 4667 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10309255 | B01 - Piano Interrato ELETTRICO | 4668 | Livello: B01 - Piano Interrato ELETTRICO | 0 | <non associato> | 0.3 | Dati identità - Commenti: Aula magna
10309631 | L00 - Piano Terra Piazza ELETTRICO | 4669 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofase (442)
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Alimentazione monofase; Tipologia presa: Alim. mono.
Type - Dati identità - Contrassegno tipo: 1; Nome del tipo: EFX_I_Alim.NeMonofase; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Alim.NeMonofase
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Alim.NeMonofase
Material: Placca, Metallo
Altro - Famiglia: Alimentazione monofase: EFX_I_Alim.NeMonofase; Famiglia e tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase; ID tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase; Tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase
Dimensioni - Area: 0.0113601 m2; Volume: 0.0000363445 m3
Elettrico - Load: 100 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-100 W
Fasi - Fase di creazione: Nuova costruzione
Name (Alimentazione monofase:EFX_I_Alim.NeMonofase:...) | In | Contrassegno | Distanza_simbolo (m) | Nome dispositivo | Livello = Livello abaco | Offset da host (m) | Quota altimetrica da livello (m) | Host
9699085 | L00 - Piano Terra Piazza ELETTRICO | 4231 | 0.5 | Fila 1 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699086 | L00 - Piano Terra Piazza ELETTRICO | 4232 | 0.5 | Fila 2 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699087 | L00 - Piano Terra Piazza ELETTRICO | 4233 | 0.5 | Fila 3 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699088 | L00 - Piano Terra Piazza ELETTRICO | 4234 | 0.5 | Fila 4 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699089 | L00 - Piano Terra Piazza ELETTRICO | 4235 | 0.5 | Fila 5 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699090 | L00 - Piano Terra Piazza ELETTRICO | 4236 | 0.5 | Fila 6 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699091 | L00 - Piano Terra Piazza ELETTRICO | 4237 | 0.5 | Fila 7 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699092 | L00 - Piano Terra Piazza ELETTRICO | 4238 | 0.5 | Fila 8 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699093 | L00 - Piano Terra Piazza ELETTRICO | 4239 | 0.5 | Fila 9 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699094 | L00 - Piano Terra Piazza ELETTRICO | 4240 | 0.5 | Fila 10 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699209 | L00 - Piano Terra Piazza ELETTRICO | 4241 | 0.5 | Fila 1 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699210 | L00 - Piano Terra Piazza ELETTRICO | 4242 | 0.5 | Fila 2 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699211 | L00 - Piano Terra Piazza ELETTRICO | 4243 | 0.5 | Fila 3 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699212 | L00 - Piano Terra Piazza ELETTRICO | 4244 | 0.5 | Fila 4 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699213 | L00 - Piano Terra Piazza ELETTRICO | 4245 | 0.5 | Fila 5 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699214 | L00 - Piano Terra Piazza ELETTRICO | 4246 | 0.5 | Fila 6 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699215 | L00 - Piano Terra Piazza ELETTRICO | 4247 | 0.5 | Fila 7 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699216 | L00 - Piano Terra Piazza ELETTRICO | 4248 | 0.5 | Fila 8 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699217 | L00 - Piano Terra Piazza ELETTRICO | 4249 | 0.5 | Fila 9 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699218 | L00 - Piano Terra Piazza ELETTRICO | 4250 | 0.5 | Fila 10 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699330 | L00 - Piano Terra Piazza ELETTRICO | 4253 | 0.5 | Fila 1 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699361 | L00 - Piano Terra Piazza ELETTRICO | 4254 | 0.5 | Fila 2 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699369 | L00 - Piano Terra Piazza ELETTRICO | 4255 | 0.5 | Fila 3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699381 | L00 - Piano Terra Piazza ELETTRICO | 4256 | 0.5 | Fila 4 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699391 | L00 - Piano Terra Piazza ELETTRICO | 4257 | 0.5 | Fila 5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699401 | L00 - Piano Terra Piazza ELETTRICO | 4258 | 0.5 | Fila 6 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699411 | L00 - Piano Terra Piazza ELETTRICO | 4259 | 0.5 | Fila 7 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699419 | L00 - Piano Terra Piazza ELETTRICO | 4260 | 0.5 | Fila 8 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699539 | L00 - Piano Terra Piazza ELETTRICO | 4261 | 0.5 | Fila 10 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699613 | L00 - Piano Terra Piazza ELETTRICO | 4262 | 0.5 | Fila 9 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699621 | L00 - Piano Terra Piazza ELETTRICO | 4263 | 0.5 | Fila 8 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699631 | L00 - Piano Terra Piazza ELETTRICO | 4264 | 0.5 | Fila 7 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699643 | L00 - Piano Terra Piazza ELETTRICO | 4265 | 0.5 | Fila 6 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699653 | L00 - Piano Terra Piazza ELETTRICO | 4266 | 0.5 | Fila 5 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699663 | L00 - Piano Terra Piazza ELETTRICO | 4267 | 0.5 | Fila 4 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699673 | L00 - Piano Terra Piazza ELETTRICO | 4268 | 0.5 | Fila 3 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699681 | L00 - Piano Terra Piazza ELETTRICO | 4269 | 0.5 | Fila 2 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699693 | L00 - Piano Terra Piazza ELETTRICO | 4270 | 0.5 | Fila 1 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699718 | L00 - Piano Terra Piazza ELETTRICO | 4271 | 0.5 | Fila 10 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699719 | L00 - Piano Terra Piazza ELETTRICO | 4272 | 0.5 | Fila 9 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699720 | L00 - Piano Terra Piazza ELETTRICO | 4273 | 0.5 | Fila 8 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699721 | L00 - Piano Terra Piazza ELETTRICO | 4274 | 0.5 | Fila 7 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699722 | L00 - Piano Terra Piazza ELETTRICO | 4275 | 0.5 | Fila 6 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699723 | L00 - Piano Terra Piazza ELETTRICO | 4276 | 0.5 | Fila 5 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699724 | L00 - Piano Terra Piazza ELETTRICO | 4277 | 0.5 | Fila 4 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699725 | L00 - Piano Terra Piazza ELETTRICO | 4278 | 0.5 | Fila 3 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699726 | L00 - Piano Terra Piazza ELETTRICO | 4279 | 0.5 | Fila 2 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9699727 | L00 - Piano Terra Piazza ELETTRICO | 4280 | 0.5 | Fila 1 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700360 | L00 - Piano Terra Piazza ELETTRICO | 4285 | 0.5 | Fila 1 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700361 | L00 - Piano Terra Piazza ELETTRICO | 4286 | 0.5 | Fila 1 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700376 | L00 - Piano Terra Piazza ELETTRICO | 4287 | 0.5 | Fila 2 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700377 | L00 - Piano Terra Piazza ELETTRICO | 4288 | 0.5 | Fila 2 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700386 | L00 - Piano Terra Piazza ELETTRICO | 4289 | 0.5 | Fila 3 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700387 | L00 - Piano Terra Piazza ELETTRICO | 4290 | 0.5 | Fila 3 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700396 | L00 - Piano Terra Piazza ELETTRICO | 4291 | 0.5 | Fila 4 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700397 | L00 - Piano Terra Piazza ELETTRICO | 4292 | 0.5 | Fila 4 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700406 | L00 - Piano Terra Piazza ELETTRICO | 4293 | 0.5 | Fila 5 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700407 | L00 - Piano Terra Piazza ELETTRICO | 4294 | 0.5 | Fila 5 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700416 | L00 - Piano Terra Piazza ELETTRICO | 4295 | 0.5 | Fila 6 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700417 | L00 - Piano Terra Piazza ELETTRICO | 4296 | 0.5 | Fila 6 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700436 | L00 - Piano Terra Piazza ELETTRICO | 4297 | 0.5 | Fila 7 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700437 | L00 - Piano Terra Piazza ELETTRICO | 4298 | 0.5 | Fila 7 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700499 | L00 - Piano Terra Piazza ELETTRICO | 4301 | 0.5 | Fila 1 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700500 | L00 - Piano Terra Piazza ELETTRICO | 4302 | 0.5 | Fila 1 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700501 | L00 - Piano Terra Piazza ELETTRICO | 4303 | 0.5 | Fila 2 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700502 | L00 - Piano Terra Piazza ELETTRICO | 4304 | 0.5 | Fila 2 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700503 | L00 - Piano Terra Piazza ELETTRICO | 4305 | 0.5 | Fila 3 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700504 | L00 - Piano Terra Piazza ELETTRICO | 4306 | 0.5 | Fila 3 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700505 | L00 - Piano Terra Piazza ELETTRICO | 4307 | 0.5 | Fila 4 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700506 | L00 - Piano Terra Piazza ELETTRICO | 4308 | 0.5 | Fila 4 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700507 | L00 - Piano Terra Piazza ELETTRICO | 4309 | 0.5 | Fila 5 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700508 | L00 - Piano Terra Piazza ELETTRICO | 4310 | 0.5 | Fila 5 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700509 | L00 - Piano Terra Piazza ELETTRICO | 4311 | 0.5 | Fila 6 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700510 | L00 - Piano Terra Piazza ELETTRICO | 4312 | 0.5 | Fila 6 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700511 | L00 - Piano Terra Piazza ELETTRICO | 4313 | 0.5 | Fila 7 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700512 | L00 - Piano Terra Piazza ELETTRICO | 4314 | 0.5 | Fila 7 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9700816 | L00 - Piano Terra Piazza ELETTRICO | 4316 | 0.5 | Fila 1 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701015 | L00 - Piano Terra Piazza ELETTRICO | 4317 | 0.5 | Fila 2 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701025 | L00 - Piano Terra Piazza ELETTRICO | 4318 | 0.5 | Fila 3 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701033 | L00 - Piano Terra Piazza ELETTRICO | 4319 | 0.5 | Fila 4 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701045 | L00 - Piano Terra Piazza ELETTRICO | 4320 | 0.5 | Fila 5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701055 | L00 - Piano Terra Piazza ELETTRICO | 4321 | 0.5 | Fila 6 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701065 | L00 - Piano Terra Piazza ELETTRICO | 4322 | 0.5 | Fila 7 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701075 | L00 - Piano Terra Piazza ELETTRICO | 4323 | 0.5 | Fila 8 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9701085 | L00 - Piano Terra Piazza ELETTRICO | 4324 | 0.5 | Fila 9 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717510 | L00 - Piano Terra Piazza ELETTRICO | 4325 | 0.5 | Fila 1 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717550 | L00 - Piano Terra Piazza ELETTRICO | 4326 | 0.5 | Fila 2 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717558 | L00 - Piano Terra Piazza ELETTRICO | 4327 | 0.5 | Nome | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717568 | L00 - Piano Terra Piazza ELETTRICO | 4328 | 0.5 | Fila 3 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717600 | L00 - Piano Terra Piazza ELETTRICO | 4329 | 0.5 | Fila 4 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717610 | L00 - Piano Terra Piazza ELETTRICO | 4330 | 0.5 | Fila 5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717620 | L00 - Piano Terra Piazza ELETTRICO | 4331 | 0.5 | Fila 6 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717630 | L00 - Piano Terra Piazza ELETTRICO | 4332 | 0.5 | Fila 7 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717640 | L00 - Piano Terra Piazza ELETTRICO | 4333 | 0.5 | Fila 8 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717652 | L00 - Piano Terra Piazza ELETTRICO | 4334 | 0.5 | Fila 9 | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717684 | L00 - Piano Terra Piazza ELETTRICO | 4335 | 0.5 | Fila 14 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717697 | L00 - Piano Terra Piazza ELETTRICO | 4336 | 0.5 | Fila 14 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717732 | L00 - Piano Terra Piazza ELETTRICO | 4337 | 0.5 | Fila 13 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717733 | L00 - Piano Terra Piazza ELETTRICO | 4338 | 0.5 | Fila 13 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717741 | L00 - Piano Terra Piazza ELETTRICO | 4339 | 0.5 | Fila 12 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717742 | L00 - Piano Terra Piazza ELETTRICO | 4340 | 0.5 | Fila 12 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717750 | L00 - Piano Terra Piazza ELETTRICO | 4341 | 0.5 | Fila 11 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717751 | L00 - Piano Terra Piazza ELETTRICO | 4342 | 0.5 | Fila 11 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717759 | L00 - Piano Terra Piazza ELETTRICO | 4343 | 0.5 | Fila 10 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717760 | L00 - Piano Terra Piazza ELETTRICO | 4344 | 0.5 | Fila 10 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717770 | L00 - Piano Terra Piazza ELETTRICO | 4345 | 0.5 | Fila 9 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717771 | L00 - Piano Terra Piazza ELETTRICO | 4346 | 0.5 | Fila 9 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717781 | L00 - Piano Terra Piazza ELETTRICO | 4347 | 0.5 | Fila 8 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717782 | L00 - Piano Terra Piazza ELETTRICO | 4348 | 0.5 | Fila 8 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717790 | L00 - Piano Terra Piazza ELETTRICO | 4349 | 0.5 | Fila 7 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717791 | L00 - Piano Terra Piazza ELETTRICO | 4350 | 0.5 | Fila 7 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717799 | L00 - Piano Terra Piazza ELETTRICO | 4351 | 0.5 | Fila 6 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717800 | L00 - Piano Terra Piazza ELETTRICO | 4352 | 0.5 | Fila 6 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717808 | L00 - Piano Terra Piazza ELETTRICO | 4353 | 0.5 | Fila 5 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717809 | L00 - Piano Terra Piazza ELETTRICO | 4354 | 0.5 | Fila 5 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717823 | L00 - Piano Terra Piazza ELETTRICO | 4355 | 0.5 | Fila 4 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717824 | L00 - Piano Terra Piazza ELETTRICO | 4356 | 0.5 | Fila 4 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717832 | L00 - Piano Terra Piazza ELETTRICO | 4357 | 0.5 | Fila 3 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717833 | L00 - Piano Terra Piazza ELETTRICO | 4358 | 0.5 | Fila 3 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717841 | L00 - Piano Terra Piazza ELETTRICO | 4359 | 0.5 | Fila 2 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717842 | L00 - Piano Terra Piazza ELETTRICO | 4360 | 0.5 | Fila 2 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717850 | L00 - Piano Terra Piazza ELETTRICO | 4361 | 0.5 | Fila 1 DX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9717851 | L00 - Piano Terra Piazza ELETTRICO | 4362 | 0.5 | Fila 1 SX | Livello: L01 - Piano Primo ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9723557 | L02 - Piano Secondo ELETTRICO | 4425 | 0.5 | Alim.ne recuperatore | Livello: L02 - Piano Secondo ELETTRICO | -1.40595 | 3.21109 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
9723755 | L02 - Piano Secondo ELETTRICO | 4427 | 0.478404 | Alim.ne estrattore | Livello: L02 - Piano Secondo ELETTRICO | 2.91053 | 3.21109 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
9723991 | L02 - Piano Secondo ELETTRICO | 4428 | 0.5 | Alim.ne recuperatore | Livello: L02 - Piano Secondo ELETTRICO | -1.27723 | 3.15193 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
9724015 | L02 - Piano Secondo ELETTRICO | 4429 | 0.5 | Alim.ne recuperatore | Livello: L02 - Piano Secondo ELETTRICO | -2.83483 | 3.20121 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
9724048 | L02 - Piano Secondo ELETTRICO | 4430 | 0.5 | Alim.ne estrattore | Livello: L02 - Piano Secondo ELETTRICO | -0.598954 | 3.2738 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
9742958 | L00 - Piano Terra Piazza ELETTRICO | 4435 | 0.5 | Alim.ne collettori | Livello: L01 - Piano Primo ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9743037 | L00 - Piano Terra Piazza ELETTRICO | 4436 | 0.5 | Alim.ne collettori | Livello: L01 - Piano Primo ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9743054 | L00 - Piano Terra Piazza ELETTRICO | 4437 | 0.5 | Alim.ne collettori | Livello: L01 - Piano Primo ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9743379 | L00 - Piano Terra Piazza ELETTRICO | 4438 | 0.5 | Alim.ne collettori | Livello: L01 - Piano Primo ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9743796 | L00 - Piano Terra Piazza ELETTRICO | 4439 | 0.5 | Alim.ne collettori | Livello: L01 - Piano Primo ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9744051 | L00 - Piano Terra Piazza ELETTRICO | 4440 | 0.5 | Alim.ne collettori | Livello: L01 - Piano Primo ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9744265 | L00 - Piano Terra Piazza ELETTRICO | 4441 | 0.5 | Alim.ne collettori | Livello: L01 - Piano Primo ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9744658 | L00 - Piano Terra Piazza ELETTRICO | 4442 | 0.5 | Alim.ne estrattore | Livello: L01 - Piano Primo ELETTRICO | 2.89255 | 3.60031 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9744718 | L00 - Piano Terra Piazza ELETTRICO | 4443 | 0.5 | Alim.ne recuperatore | Livello: L01 - Piano Primo ELETTRICO | -1.21533 | 3.70622 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
9744759 | L00 - Piano Terra Piazza ELETTRICO | 4444 | 0.519614 | Alim.ne estrattore | Livello: L01 - Piano Primo ELETTRICO | 2.53734 | 3.70622 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
9744991 | L00 - Piano Terra Piazza ELETTRICO | 4445 | 0.5 | Alim.ne estrattore | Livello: L01 - Piano Primo ELETTRICO | 0.859679 | 3.2878 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9745009 | L00 - Piano Terra Piazza ELETTRICO | 4446 | 0.5 | Alim.ne estrattore | Livello: L01 - Piano Primo ELETTRICO | 1.18239 | 3.30109 | <non associato>
9748303 | L00 - Piano Terra Piazza ELETTRICO | 4448 | 0.5 | Alim.ne collettori | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9748390 | L00 - Piano Terra Piazza ELETTRICO | 4449 | 0.5 | Alim.ne collettori | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9748418 | L00 - Piano Terra Piazza ELETTRICO | 4450 | 0.5 | Alim.ne collettori | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9749037 | L00 - Piano Terra Piazza ELETTRICO | 4451 | 0.5 | Alim.ne collettori | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9749224 | L00 - Piano Terra Piazza ELETTRICO | 4452 | 0.5 | Alim.ne collettori | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9750547 | L00 - Piano Terra Piazza ELETTRICO | 4470 | 0.5 | Alim.ne fancoil | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9750578 | L00 - Piano Terra Piazza ELETTRICO | 4471 | 0.5 | Alim.ne fancoil | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9750933 | L00 - Piano Terra Piazza ELETTRICO | 4482 | 0.5 | Alim.ne fancoil | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
9751007 | L00 - Piano Terra Piazza ELETTRICO | 4483 | 0.5 | Alim.ne fancoil | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
9751270 | L00 - Piano Terra Piazza ELETTRICO | 4484 | 0.5 | Alim.ne fancoil | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
9751364 | B01 - Piano Interrato ELETTRICO | 4485 | 0.5 | Alim.ne fancoil | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
9752012 | L00 - Piano Terra Piazza ELETTRICO | 4486 | 0.5 | Alim.ne estrattore | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.05 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9752212 | L00 - Piano Terra Piazza ELETTRICO | 4487 | 0.5 | Alim.ne recuperatore | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.05 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9752284 | L00 - Piano Terra Piazza ELETTRICO | 4488 | 0.495372 | Alim.ne estrattore | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.05 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9752605 | L00 - Piano Terra Piazza ELETTRICO | 4489 | 0.5 | Alim.ne estrattore | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.05 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9752802 | L00 - Piano Terra Piazza ELETTRICO | 4490 | 0.372515 | Alim.ne estrattore | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.05 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
9756807 | B01 - Piano Interrato ELETTRICO | 4526 | 0.5 | Alim.ne contatore ad impulsi | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9757068 | B01 - Piano Interrato ELETTRICO | 4527 | 0.5 | Alim.ne estrattore | Livello: B01 - Piano Interrato ELETTRICO | 0.0867197 | 2.51328 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10294615 | B01 - Piano Interrato ELETTRICO | 4563 | 0.5 | Alim.ne fancoil | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10294651 | B01 - Piano Interrato ELETTRICO | 4564 | 0.5 | Alim.ne fancoil | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10294762 | B01 - Piano Interrato ELETTRICO | 4565 | 0.5 | Alim.ne fancoil | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10294956 | L00 - Piano Terra Piazza ELETTRICO | 4566 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10295002 | L00 - Piano Terra Piazza ELETTRICO | 4567 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10295065 | L00 - Piano Terra Piazza ELETTRICO | 4568 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10295076 | L00 - Piano Terra Piazza ELETTRICO | 4569 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10297114 | L00 - Piano Terra Piazza ELETTRICO | 4581 | 0.5 | Alim.ne VRV | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.75866 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
10297230 | L00 - Piano Terra Piazza ELETTRICO | 4582 | 0.5 | Alim.ne VRV | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.49034 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
10297641 | L00 - Piano Terra Piazza ELETTRICO | 4585 | 0.5 | Alim.ne VRV | Livello: L00 - Piano Terra Piazza ELETTRICO | 1.5 | 4.4579 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
10298024 | L00 - Piano Terra Piazza ELETTRICO | 4589 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10298057 | L00 - Piano Terra Piazza ELETTRICO | 4590 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10298110 | L00 - Piano Terra Piazza ELETTRICO | 4591 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10298121 | L00 - Piano Terra Piazza ELETTRICO | 4592 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10298346 | L00 - Piano Terra Piazza ELETTRICO | 4593 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10298371 | L00 - Piano Terra Piazza ELETTRICO | 4594 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
10298400 | L00 - Piano Terra Piazza ELETTRICO | 4595 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10299058 | L00 - Piano Terra Piazza ELETTRICO | 4597 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10299084 | L00 - Piano Terra Piazza ELETTRICO | 4598 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10299143 | L00 - Piano Terra Piazza ELETTRICO | 4599 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10299393 | L00 - Piano Terra Piazza ELETTRICO | 4600 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10300017 | L00 - Piano Terra Piazza ELETTRICO | 4603 | 0.5 | Alim.ne boiler | Livello: L01 - Piano Primo ELETTRICO | -0.213131 | 3.30001 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
10300071 | L00 - Piano Terra Piazza ELETTRICO | 4604 | 0.5 | Alim.ne boiler | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.64 | 3.51862 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10300123 | L00 - Piano Terra Piazza ELETTRICO | 4605 | 0.5 | Alim.ne boiler | Livello: L00 - Piano Terra Piazza ELETTRICO | -17.0029 | 3.51862 | <non associato>
10300685 | L00 - Piano Terra Piazza ELETTRICO | 4608 | 0.5 | Alim.ne VRV | Livello: L01 - Piano Primo ELETTRICO | 1.96597 | 3.91019 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
10301628 | L00 - Piano Terra Piazza ELETTRICO | 4615 | 0.5 | Alim.ne VRV | Livello: L01 - Piano Primo ELETTRICO | 1.61099 | 3.97019 | <non associato>
10301674 | L00 - Piano Terra Piazza ELETTRICO | 4616 | 0.5 | Alim.ne VRV | Livello: L01 - Piano Primo ELETTRICO | 35.811 | 3.97019 | <non associato>
10302061 | L00 - Piano Terra Piazza ELETTRICO | 4618 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10302076 | L00 - Piano Terra Piazza ELETTRICO | 4619 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
