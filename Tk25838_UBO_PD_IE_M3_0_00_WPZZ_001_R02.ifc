Properties of the parts of a building model (IFC4), part 15 of 23

# IfcLightFixture: LFX_I_GewissGws3221Ap940:LFX_I_GewissGws3221Ap940 (96)
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_GewissGws3221Ap940
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_GewissGws3221Ap940; TotalWattage: 1 W
Altro - Famiglia: LFX_I_GewissGws3221Ap940: LFX_I_GewissGws3221Ap940; Famiglia e tipo: LFX_I_GewissGws3221Ap940: LFX_I_GewissGws3221Ap940; ID tipo: LFX_I_GewissGws3221Ap940: LFX_I_GewissGws3221Ap940; Tipo: LFX_I_GewissGws3221Ap940: LFX_I_GewissGws3221Ap940
Costruzione - CFG_: 1_1001614
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Name (LFX_I_GewissGws3221Ap940:LFX_I_GewissGws3221Ap940:...) | In | Contrassegno | Host | Livello = Livello abaco | Quota altimetrica da livello (m)
8654683 | B01 - Piano Interrato ELETTRICO | 3783 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.5
8656637 | B01 - Piano Interrato ELETTRICO | 3784 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.5
8656648 | B01 - Piano Interrato ELETTRICO | 3785 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.5
8656657 | B01 - Piano Interrato ELETTRICO | 3786 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656686 | B01 - Piano Interrato ELETTRICO | 3787 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656695 | B01 - Piano Interrato ELETTRICO | 3788 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656705 | B01 - Piano Interrato ELETTRICO | 3789 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656715 | B01 - Piano Interrato ELETTRICO | 3790 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656723 | B01 - Piano Interrato ELETTRICO | 3791 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656756 | B01 - Piano Interrato ELETTRICO | 3792 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.5
8656786 | B01 - Piano Interrato ELETTRICO | 3793 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.5
8656794 | B01 - Piano Interrato ELETTRICO | 3794 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656803 | B01 - Piano Interrato ELETTRICO | 3795 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656812 | B01 - Piano Interrato ELETTRICO | 3796 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656820 | B01 - Piano Interrato ELETTRICO | 3797 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656830 | B01 - Piano Interrato ELETTRICO | 3798 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656838 | B01 - Piano Interrato ELETTRICO | 3799 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656864 | B01 - Piano Interrato ELETTRICO | 3800 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8656907 | B01 - Piano Interrato ELETTRICO | 3801 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8657000 | B01 - Piano Interrato ELETTRICO | 3802 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8657008 | B01 - Piano Interrato ELETTRICO | 3803 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.55
8657114 | B01 - Piano Interrato ELETTRICO | 3804 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657196 | B01 - Piano Interrato ELETTRICO | 3806 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657205 | B01 - Piano Interrato ELETTRICO | 3807 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657217 | B01 - Piano Interrato ELETTRICO | 3808 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657227 | B01 - Piano Interrato ELETTRICO | 3809 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657238 | B01 - Piano Interrato ELETTRICO | 3810 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657249 | B01 - Piano Interrato ELETTRICO | 3811 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657283 | B01 - Piano Interrato ELETTRICO | 3814 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657297 | B01 - Piano Interrato ELETTRICO | 3815 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657305 | B01 - Piano Interrato ELETTRICO | 3816 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657315 | B01 - Piano Interrato ELETTRICO | 3817 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657325 | B01 - Piano Interrato ELETTRICO | 3818 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657335 | B01 - Piano Interrato ELETTRICO | 3819 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657343 | B01 - Piano Interrato ELETTRICO | 3820 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657354 | B01 - Piano Interrato ELETTRICO | 3821 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657364 | B01 - Piano Interrato ELETTRICO | 3822 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657372 | B01 - Piano Interrato ELETTRICO | 3823 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657383 | B01 - Piano Interrato ELETTRICO | 3824 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657392 | B01 - Piano Interrato ELETTRICO | 3825 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657400 | B01 - Piano Interrato ELETTRICO | 3826 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657409 | B01 - Piano Interrato ELETTRICO | 3827 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657419 | B01 - Piano Interrato ELETTRICO | 3828 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657427 | B01 - Piano Interrato ELETTRICO | 3829 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657437 | B01 - Piano Interrato ELETTRICO | 3830 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657445 | B01 - Piano Interrato ELETTRICO | 3831 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657548 | B01 - Piano Interrato ELETTRICO | 3832 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657558 | B01 - Piano Interrato ELETTRICO | 3833 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657568 | B01 - Piano Interrato ELETTRICO | 3834 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657578 | B01 - Piano Interrato ELETTRICO | 3835 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.65
8657587 | B01 - Piano Interrato ELETTRICO | 3836 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8657598 | B01 - Piano Interrato ELETTRICO | 3837 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8658367 | L00 - Piano Terra Piazza ELETTRICO | 3845 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658393 | L00 - Piano Terra Piazza ELETTRICO | 3846 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658418 | L00 - Piano Terra Piazza ELETTRICO | 3847 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658426 | L00 - Piano Terra Piazza ELETTRICO | 3848 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8831554 | B01 - Piano Interrato ELETTRICO | 4891 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
8831574 | B01 - Piano Interrato ELETTRICO | 4895 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
9430107 | L00 - Piano Terra Piazza ELETTRICO | 5071 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9430118 | L00 - Piano Terra Piazza ELETTRICO | 5072 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9435500 | L00 - Piano Terra Piazza ELETTRICO | 5081 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9435501 | L00 - Piano Terra Piazza ELETTRICO | 5082 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9439128 | L02 - Piano Secondo ELETTRICO | 5125 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 2.64774
9439166 | L00 - Piano Terra Piazza ELETTRICO | 5126 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4.37909
9439193 | L00 - Piano Terra Piazza ELETTRICO | 5127 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 2.5
9439229 | L00 - Piano Terra Piazza ELETTRICO | 5128 | <non associato> | Livello: L00 - Piano Terra Piazza ELETTRICO | 5.2032
9439296 | L00 - Piano Terra Piazza ELETTRICO | 5129 | <non associato> | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.8
9440868 | L02 - Piano Secondo ELETTRICO | 5139 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 2.8
9441100 | L02 - Piano Secondo ELETTRICO | 5140 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 2.8
9444800 | L00 - Piano Terra Piazza ELETTRICO | 5250 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 2.5
9444833 | L00 - Piano Terra Piazza ELETTRICO | 5251 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 2.5
9446490 | B01 - Piano Interrato ELETTRICO | 5252 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
9446532 | B01 - Piano Interrato ELETTRICO | 5253 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
9446570 | B01 - Piano Interrato ELETTRICO | 5254 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
9446583 | B01 - Piano Interrato ELETTRICO | 5255 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
9446621 | B01 - Piano Interrato ELETTRICO | 5256 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 2.6
9447621 | B01 - Piano Interrato ELETTRICO | 5273 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 3.04
9447718 | B01 - Piano Interrato ELETTRICO | 5274 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 3.04
9447743 | B01 - Piano Interrato ELETTRICO | 5275 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 3.04
9447768 | B01 - Piano Interrato ELETTRICO | 5276 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 3.04
9447814 | B01 - Piano Interrato ELETTRICO | 5277 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 3.299
9447867 | B01 - Piano Interrato ELETTRICO | 5278 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 3.299
9447884 | B01 - Piano Interrato ELETTRICO | 5279 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 3.299
9447943 | B01 - Piano Interrato ELETTRICO | 5280 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 3.299
9447996 | B01 - Piano Interrato ELETTRICO | 5281 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.5
9448164 | B01 - Piano Interrato ELETTRICO | 5282 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.5
9448181 | B01 - Piano Interrato ELETTRICO | 5283 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.5
9448195 | B01 - Piano Interrato ELETTRICO | 5284 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.5
9456259 | L02 - Piano Secondo ELETTRICO | 5401 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 4.15
9456391 | L03 - Piano Terzo ELETTRICO | 5405 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L03 - Piano Terzo ELETTRICO | 2.126
9456424 | L03 - Piano Terzo ELETTRICO | 5406 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L03 - Piano Terzo ELETTRICO | 2.126
9456469 | L03 - Piano Terzo ELETTRICO | 5407 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L03 - Piano Terzo ELETTRICO | 2.126
9492142 | B01 - Piano Interrato ELETTRICO | 5426 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 3.299
9549156 | B01 - Piano Interrato ELETTRICO | 6072 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.5
9549179 | B01 - Piano Interrato ELETTRICO | 6073 | <non associato> | Livello: B01 - Piano Interrato ELETTRICO | 2.5
9571372 | B01 - Piano Interrato ELETTRICO | 5075 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: B01 - Piano Interrato ELETTRICO | 3.25

# IfcLightFixture: LFX_I_IguzziniMod.Q515:LFX_I_IguzziniMod.Q515 (50)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniMod.Q515
Type - Costruzione - CFG_: ---_0001; Mounting Place: Ceiling; Mounting Type: Recessed
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: Q515 : Linear miniaturised recessed luminaire with 15 optical elements for LED lamps - fixed optics. Despite the ultracompact size of the product, the patented technology of the optic system guarantees an efficient flow and a high level of controlled glare visual comfort. Main body with die-cast aluminium radiant surface, version with perimeter surface frame. Metallised, thermoplastic, high definition Opti Beam reflectors, integrated in a set-back position in the anti-glare screen. Supplied with a power supply unit connected to the luminaire. Q515.01 - Frame 15 cells - Wideflood beam - LED - 30W 3300lm - 4000K - CRI 90 - White A44V - Lamp LED Neutral White CRI>90; Modello: Q515; Nome del tipo: LFX_I_IguzziniMod.Q515; Product group: recessed luminaire; Product Name: Laser Blade XS High Contrast; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___q515/
Type - Dimensioni - Height: 0 m; Length: 0.28 m; Weight: 0 kg; Width: 0.028 m
Type - Elettrico - Number of Poles: 1; Commenti sul wattaggio: 1; Lampada: 1 x LED; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 33.8 W; Voltage: 0 V
Type - Elettrico - Carichi - Power Factor: 1; Carico apparente: 33.8 W
Type - Elettrico - Illuminazione - Luminous efficacy: 81.0355 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 100 100 100 100 83; Color Rendering: 90; Color Temperature: 4000K; Lamp count: 1; Lamp Light Flux: 3300 lm; Lifetime: 73000 h; Socket: socket; System Light Flux: 2739 lm
Type - Generale - OnlyDefault: yes; ModVariant: no; ProductGroupID: 4; ApiVersion: 132383237; ConversionDate: 11/12/2021 12:49:52 AM; ConverterVersion: 2020.2.4.0; RlxChecksum: 64d4b7c9529e737fb62d7f69ba657d7c; RlxData: ZN3q8ryccAANEycwSthwAAAAAAAAjAAAAAAAAAJqAi0wAf7Yb7fCEQFjjkd4QJ1aKGDWGpUsPWGh9Xl8R12QHaDwZtMtB9++hxH5hdB/yUbcVMaWJWLsY/LJ0+F2mUFnyAk5QrSIIzjjLEQEPnebmKqthBOqlBJZ5KskzoYMq2cD3hNSny0q9qMNIAyDGDcKNoQQ96PqKmUK342F9ZoCgJVQgKR/NjKcv/yR2H9nRi393D7a97C5+QQyUy7k51WoJaxvamtOqhfVZC1V0jOrnvhTmlCAw7PfpWS04TBX8y+AjG6KOBpE+jEukT0BFXSVEUICzF0KwJA+sNMrzB30pGZoJLIy+Tv5UgNAjq4E0PkoKR6byONN+7rJK8Q2x2JUij84IsLr1/OEO4gT2lNs9NVobLVtCxFtqZwtSB95heWDD+AJK5j2Py62BIWiymTLOyNyXcsTeytAHAg2dpT29EioaPlcugzYW+rWrmVVUGJccyhHqgiYfk/Ohdi53/KAIVTxiHKJHuupWBplM5b9//WDn/W+rTUUJ4P/6bYAXZFt2CsO2KL+sir001iPC+yHkQ1DkFaXxaDfNDanUfGJetk1tPwsy18YCkiS+tqxew7ywDKZtS4wysBRchZ1/2JA/lK+aeqer4nnCFTaB8P42Msjw4lOsh86vK1OWU0isIBGioE9TuRFskrFRigqJ+trjRTpQyU9L5FY12D4hubvLYZZ2EQNQubt7qVuFbeQYZEBqll16VYWyti7FVbcM7TKdVbCn5eD5ykyk6HCr8rbEcbjkB/k3NakdImaeBMHXJWxPjNz7kAQOHtsZLGm3wz0MpFU6JO4dH3oM7b8z8icot+cdv2Dz+i1EM38yf+bawWlhfIrzYZyP5YaMk2omww7X/Hoh2+EjL54kvZNbnZAUyQRj8jPv4q/3JwrCGECy072A5JABbyikb2SYsC/5VWxr07hyJfjUcmOXv24VVa8+yJj5zbj35Sci8ZCzcfHPPHzlLWCn35jwr4r2X2UyECJE+YUarSU38YHA7INQgjswiPzjsFDoCTsJIvjKYW/IWLp5jees9AIaOiXvKDEyqJ7c1gwbMIrn1hUiZkelik+Xg90JkcAcRdZI83WoFkxi/i6kTa3MGi3m4Q+qYIAxB+Nt5vbsQvYEm8YKQh+A/nj5ZFv4fDx3ZDqF7uMLlP73F+47b9fZpxeUT1C/QtJ4qsKTlPXNP4isE0s1UO+IFiocr2cj5oVLLAyfPQkxKPKhaa3HTMpzfUooI6L7nbV4f2gSDTzjznh6DTr5YmozxA81/f/Kkk4fHkW1bc822UR+hqK+duY0DdpKb197x7cnYTnWQRj+Ghgo7ZfRlllK28F/gCKmy4g85SXHyjRYTNReholKcFvLt1/4/v1TuQXCgafjeSlj93jyARtRrdYNWx5e9AupyYSaDOMh7LH7Y8vhNtNWuldEP102av0RmLzQgftu07oL7hH9vquEhvEVDoI9EmRWjtNmDTKaEKJ8UMjqmd/BoqYmv4dnOBc7DhbJ4MFUGnrFU7euvCHnywIjcjCVv2BXbdAfJcb6zF/OHspPEs3yC9LMYboKXFfMs2xClCKclWgJ5YhvVZdd6kEpXYqaT2MJeSJ42YLtm9Yv/4d14H18ri1Cu9dab+OtFYFaIyMz56IuAh2qgVPgsj5ERX46J6dpabNX5LmWekzE7xZCsY/CfVeGijSxZ39P4fcCyUP1c+wD1oJNQYKs+wwpy40K7izYr8hmumbtbAXJM71tmA1in/tj6MmhaD6GHaKE5ZDdaBkK+B3Xzj2HNG9vi4mczdVaBBHCQnN/6PVoVT4y6v8gt5FiF7RjKf1ocHPYxA9OF1sQs3y+szyetckcAmEihw/NQv+skfSxnsjZVUtivCNDe1kNiGVH/rYDst27pFC6h7uO+CMYBgulXBiILfREBnVU4Serf7Pc82Lw1Z5dcGs0zqHSRlNqTGrd3PuIa14/AKM1Q/5Cw/HYVGEExyWJJCOO9wL247wROZJ5JkbswwJZnKr9cstsBfu3KxsqIZGDhiO+uP1L/x9zqCVgBWCnz0dOx6jQQZX48xZ91KrRjGxM7syNTtok5XkLS5fkSnrXXxmX00cHCmD3c2m3PS7WtrdvoPPtJISY3M0c6p76n/D9jQKrTbw66IvxZ3hM1I56ANG70558Nl1xUzQ2NPhN5+zqtSY3AAqTukuGns20iw8LXC4oCmRVNR54dCu0GkEBmL3VClyK7Jpgo4z2j0Oyo9urD0SHUPJzNKSd7LaZVZolW6LDhb2NkQbbFW75jWnKByw0OubJS7HRb0B40hdGYKWt0TQ57wzCMNdvRNpuB721N027RH5y7d1AGbopjhcaNjsTkOu2ZbeIFh8vWeYzC5r+wQokHarTa4NRvcrntRJdBXYUtGxAlWEFbznxyPkZBuDCsZKMNnz3jt0yO7jDjYN5O2BVDUx/v/N8LCRtWspmmeWPrZE/N+C1Ag2w14zgvxIv3s+T3cDozZD+zY+hahpbjBAd4N0tLQaHF9QldmHoNVoG7k8yXHfGrL3THXjLlAJg+mO1jtnm9cSTgb0neDgvQfosCEKdnXe2UdQiG/Q9ML2ymnnpQ7g0KEiz9klh9f5blkNiFjoXEMgQtgP++Dw3VW9q6GjX6+4apftlSwoqHqu6FHlv9ApGnhYvxYOBHX0PUParQfnCQsAPXUMKaRDUcr7OS4enOImFlBh6Fl1+AO9ePakMIJouEdjyQ6r6lO3RF2n9UAm3Jyjs26aUMAIhz4krw9IrrApcZvkys+GJ1bEkv/cEXf4BGBdML6BKFvXRzfMEQQd+JyTQ/YU+rlZmlYk1snWqU/ZbH9C96Vcuexar0BfCIulxwEfLaLiC1proIAnP4a36BrnVq0MJ2Q9ZYpnLQ/g47DmkpIa2IuMqGd/rnrAW7iPvnXRokaCzQwsX7i+RH7U8DerXSFXouXcqbR4VXrWzMAWWl5LBwpfSOULsHww7byOOsmICHk9pCnWt4iybXILZ9BohX96eMaYYsQqgjJDkCSDTCzt7SUmd+VA0E14Yg7cZvupvU/IWbUpjIZfP1zCPVAjKX30Jm6YdGQU+Yr6RYl0JKxk1ebM+1IoomUjd03yTi8GLiTrjMHeMyaGkNzfgZ7jLxOnsjlmlmvY2y02mNLSvvr5hwP31wLBvRwHIKPWjvoBPbWM5XbMVhDD+zszGPd7CdV3TEyHeK56bToor4hf5iPxCevR7CYCOX3Ts+Vkc6d84KwzMeXLxdpkvRiwydXZbgQPMnJPEmwKtXa6YirEjjE6LgrcG1NS0O0DquGGUH6okN17BDor+lHoF1SIl/U79nv2Ba5f4OaTN8VvpZ4fYxj8iTFwcO28IJk+DY7U/k1HpLQDb2cGXtwfsWWidGw/gNn9rYS8B43ko+mSaz3OjWiT9aS0Sah/mC2a4uwC/x8WeaEDsg9W8j14KwF8SEo54sThmWIYLjr4bQdN8AWR20aESASiL6zyqEvU4q1KCLdJHiyQYThsARfE2ibl79sOINk4dIFjjqKVnWEKr6AK6tQUQ6kBdtNGLXaPw/J9sU+cu/fTm3FSke/67CUIm+D+2xrGJhX2Pl1QFDgOEM7lJPt8XRfN6Yz1+bRqyxB5HHtbMbqEfsx+9LIFCpi58bZ1aLlckDri4Q5BlunOttYNszLsBdv19PrhMiI/oX8zi4HVNk/TXc3W5NfkFwCiP7FEyOHIV8BYIZES7h8aylI5MiAvV4Pu0u1v2f3JvHs3eOHDO9x7tWCb0xCKrAOM/V0aBVA5W5VwXnHSLZBnkSt1TkTIA3pm+Rl/n9Tvqo9qlHxLsrZECRlsWSK/3vp8YPI/2Dz/5u4LjcIGRZDEDaUFeDp79Z9FXcDyTqkURHeJI+NtJnOvIRqOtni3tyHdiBGLAaiPxTJhd0rA0/s4t0QS+mE+ksJnRtEZuiqBFUNFhMYv36weSCwLk5vW6U27rEwPOf1pCQVwNQYjX4fhhG9joe+Nz7t7rk2m5xJkrLIEqKrpvxpqThdtD1PPDKMsd4SLYPg5nO3BchJmhpkOOgDz886I3P0SCuSgUuzg97vHf21fRtpVHrWduPg6pwFv7sqnTP35eSlVzN/L/Hhj7B+NHGIus7yteQge8Yg0C0hGWm4ptydQtw7EDzgyhWvbrbfKANrznOc7D9XbcE2qBPLGr6URbzKOH70oyuRglIw7/qBz1pRWTGngBSlleRUCreaCVOxdqiIYQbYQJmIW/uSl5GZLGox53w+MP9tU296n8DiM6ZIynXVJiol1gA3aJknnqj9WvvUuyE3tW7jg6XUnoVab0e534TQb6meh8CqRzQS9ec7juf33TfVSH4nsR3pr4G7GWRtF1sWta8A383HaPwlDLE/GqR6OHwOYdUBbVoe/0zMBlxh7dDt2tRkGVBuP0NOLuhO4k7WZqht9467zIAUYmLWMvbhP3IDVqn8I7H3ICDVqzHc874VTyDtV7WszeJIdAfcX7GEnpVftaIfe2sVnbmTtUUmVllTu5vPN31nR4oqujihijBQVKkENTnRYMLr3y8SdGGA2M29+4cpc3EOp1xb6gZWicEsu0MIph9oeJ0qo36dsUBpJSRy1rVD3WbN+QbLeVB7dRgSFvNMt0JfUHmn0YrRoBKXfR8AKslpBAECPDdL9Vdy/AlrITJ0rvQerd8XiPLw2gGVO50tfn5AXQqaMa/hjNsRVkyZruYdeYrJvJ4FmXmGhKk615ddYUhyUh75E1xZlXr9L2sZU9R9Z0q5pSyEosWu7tADC50mIpsx+1653H4fr2p7TKXfuXT/f792XIrKnahAANg2SuuhY0JMyv3sHzwWSfv+8iSpXPxa4LgPhwgnrG1rk27kgqH3X8vk26LKWvc4XVBRg3Rir5Ntxzodn2eZWDLEc5P7cUAFmChSjL7EudNxlBD7IWfbpsh2p1aZrtHZmR2JCVOn5QMSBpvCeoymnCxn7XWVEEzf1DBCT5uq723PMLZFkAX7MGtUEQYi8msgtXnrLt5MRFtlvALMnoisihxZB98lCkhG3jDmolsm/KnHQw72tFUdXb+vwzS5UlVeI/eXdGOLDWJR0wUzPg/UrGgHhWzIrYOm4f5y9fPTciG1NOsU+o9DFTp7IspHHBOK72DcAOEEatS9rxtO3uAn3zkZ9vWyy4XMQrlR/xhBIrII/ZtrA4EIxQLpdrTvUKASQUdm3LkSErd8246WyJcCB/02wxn1bDVxh7+EMtOzrLw7WieZcBJbYhRiqxn/Pj44V0slfj59b7v9URoKu6ZJD50n95q7L6p41b9tK8scJwcTHD8zIb6mSwQAomPH8MlbCVGQBz9Fzq/wlsGtfIaUYD8obVsdMFrFAn92KVuz8eG8FxlwlhDr/Kg3JNVxa10L66lNEN+iuxFmwoTT5JKb8Tq76Fkqw7MZJbAXHJrbLqpnFpywHVXP4CMkBhfeuL+n3853nQuQLzyBJEP6tkoUMRAE+srozJX4gYpsV/RC4EODoD5RE/oQkcQpUlJXFROZ88DtarBccMcby4z8R0xKGceyw6/clzgtDNZkfE+Rf1CTLW640CzIOdm6ZYLSatJfZO0Aj7hRCWOBQBTM93fi6Qi+3Z6a9lkbU5dX3Ws0X2HCVQ9lFoRQcLj+QjbI27jCg91kdiGYu1605Cody/9fRF449WtyXcrMKR9Xlxx5nllLec+FFDF07i+RwffL9iKGBshtbmwNUTy3wydk5eBedDT5CgB81ONTLoioKzYVUo2G390d3xAGSht9tBkgpvqBEbKY5kjwpKwL6pVcXh1yOkkj/KN2hftu+Pr1G4JoeEebHj9D+b0yojpNiu++pMEAzNxIICv3ABAVqZItaH5BL3cvvAT1Xe9bg64LR8/5+V36GptLt02cKbPmPgUUGMx384pLRD/aQ4JivxVnSkkIoI+SzYxrAdt7ubA+3aJfdR99BAzN7o3+Rj5dR9bvzy+Cy6UvcI3laU6L46zDW/FqEzxCerng20GCjprmINeNfU0kKxbAzEAlMHZ8ZMaLE5iqPFrC4H++RxyhuL3EZ4p8xuSSszrqmYEVkhGeOf9tzpTjEms8E9kyYP5wfkT63x8DEFiWs0/xe9B/CFwJba3Pnj4uvV4pWdiATOOHKN3gh4Etb9CR5zEZWOOOH8bp9zuwtceOhDfoj/xKl/yFMxED2rk0ySma9s3uP7aaXvQadq2IcjPnWRfbGfbl4kohqiQxk8gMOhhiOiy9EBbXOlIE5cXPc7v8hhfU31f02rwd1urKNrvTLlFL5f/PwIVtbYiJXdoTyX9kku+aVDpjFL8K7HHhOXYXNr7bEV3HmygSDJa3LauLfwLW/nQrILkxHksB77aTbZZin87heu1qENe/IfgiiocyS79wNAAgg1BRQTWOhcrknlZqlF7xfwwbCNK4AHNzpF2ONpxl8SA5ALSgj8bTJiHCRArcbUoPXjIr6kEVCWE+hW07UKcINPd/KhEt+Ga4On1CGHLry5bLFeaaiXgcdpAHUq5D7IETT2g52rXKvyfx4s8a75o7KSYHN9Am/iSZHgDQ2gMfPF2eMbdp59itP9tUZFIIuuS3g1pnnx5NYsfTIz/EWMgoN6N4+zUfjwTH9D9m4+JdM12ilAMSMOKBS2B+rkYsITUBUypZH+z77xiNZ+Ssj2kls8OMvUGOe8S56cR0ophE9csTdkg83AWHA2JPcMnLM3Y/MYbJICgvBZlAbR+3ldLXEbK5yIZBnu3erOPTFbDW2SO9CmGk+cZW+540m+BQIp6uZhnlxSP0ECv4s81we681AlU2HxH+h+UC0zZFykUXImblKdYgGxLE2hyMicF5xbsLxS1eFE8aSOhz+AMcQsVQ/K1tU5xometXR/2sheaAAJM93uYxlYFtNYbbdY+aAduwZPXnAyzkVYuD5o1M6H0tsjcD5aPq9NsHv/K+jSQ3Agp2saka0NtCIo/mx7bxQrgGrqLmfurWuTQm8LbgWxAT1yZ3KVR1CGheWNaDD4BUQcdrn+nPZaH2DSfWmSCrU0tbaW2R1qcS0QqQKaKpSjB6nieoUBNhJjhVnVyYHmIdNqYDg1VcOOwVo+Bt6X8y+F6RzBTKJ5dtqklsvoEqaEG4IatgWuF8FcmXWj7GZelAazcQeTpOKUsvWLqBMgMqyp2AzZ5VqAUpbKOCRNXgPR5JnPVH0xPTtW1/4t/Ee0tvqrYCbuX7rxSGWfcDKfvb5+cV/hEblIUHpAAUGE5p6ApZZx279H3KsBJYyXE+PmBqXMMvixocbbHA528q4K2NvOLkGUGgL3xFP1rKj0LHoYEa/LzN3xptvEgN0fpJxUjwbqwcyvgn6Qy/8AeKyF7Fszjmjwd915vouWosAMN8Mz67Xg1vwjohwCpYUJNO+ylH8FnBRb5UDqt6RK4azjiHFwy8UWcp3TmmNeVmhEtdWpKQpIuvejSDeE28dpoGV65EsGqw+4gcJMMfWLZAcGgkjeyyyGc04uPfnjgpufZK9oX+uFn1eddPORNjYyAErhG5B+6qMtnlRrh3VbX7ctXm3ceAxFBIBLVIATr4XWcSkcdmyjSTTq3hz9ffwx9cz144jJe3aATQXlycqSu1CTclUpU0iHg5nFGpMuvbCOGN0QW6zu/Kon15XUDvayRhc7cDJrSy8Os8bcDPOaCamrPpI867FtgjJgFMi41aGFIgb9Y2WymxBAtfGuyas1uP/tAlGZ4id++BL2H87wjIvAI1v9L/vE2EMzSGYE7obfNIHIktKmwhUJd6XDO0VL47JHhYfZpl4407tw/prb0FEZeSs6pfwruhHPCIYV8TZw9XmqZrQK1SI0kWHCfOhBGSPJUaZGjwKa51VDMTrVZyA4tgCLkd/NgiME2Z8h/Gzz6394LAJRghAJ1EwRxJO3wEzpWFxNzJYqsVV1GdaDODrhprfVNH/t9foWQ4Undp/klWBXBScXG+4syLcB5M5YEyO2+/YG8bTq3Dg1spnzs2avyv2Gm+S4+Sa3ps9ZIFXRJ4qPZ32EJzuOAnk02Gersqlc4tJ6nUnmW1SGh6P188ThPRsFup48YrQUiRyLnbiWwOqAeDp+ols+zlYTMTtGsJhISYQQCKH9fiakCbu89ynj5AN/O2kQccafUFPN+2oNBAPL0ARzbHv4s6Ycin9R8GKmA8FhfTL0Y+QHDUN9MPvhrXMBqnVxO4LiUOuDqpYnRKUBM9mpLM1MHQD83NfZaM4nojz8JGAM09qPxsMD0pc4nMZWaxRb2tzcP8cePh2UYKaddFAGbQalhmyClhlviHyXCHIjYEuAQLSU1i/H4aQ1oBa/mbmaZ6jlNfX14vgnPf70hkms8jCPw8Sz+ajcr33nq1oJ7d4pXpAyYY4K/oQGiGxplFdq1QPB/lpEfMjhOWZKO6RasvmpqXUmNisr066qQ4lNEF+xbIFwoXWwopsBr8bZ+0sy7oXo0OduQ3wCJW48n8DF3SETkURYWSm2aadLkSP9B0F3mpYNSJ9Gs/Y+srhpIgJkQKhPgzTut8Ceg6712xBzw4I/mnPv8KwJj2rfw8ns0oPrHryTf0qsW2B0wouXscGWGCG8KyyasT887lLcn051DLN9eByjJwfAVxqSBF/TgfgJ5NQ7PADaqXnf6Xia9q7/0dUr2M1qiRrKeLtb7pbXS9OoF7LQaxat3gL5l1Gt5MEu+g7cNgfBo7gEwBL3cmLmkUjaf7r9lrdd3He0lX7KNnuHc0LVKOc7cMMTOfLbWy+Fv+NSieKVrR0ahdz/IizaZXB8mDR3V6clefDyz+icU7XtU80t3ohtJHzfrKVEFFhsswzsRuHvwmNZT4MGzgjwHg5BbPdA74V0yb1ymzV0yJpkyxvCsJSEIba1IzleKlSyz2wvYozMGYbhgyPQ/g2b5bjloqzDLtQkYVKedlXsINzdMDMr4bolRSw0dlSYYGWbfBC4FzfOW6pS8MRdHAkKOibrer7emPoIz2Xpw5JIrhDO0/B6gNwqDJfkCTz4eeygyYQQY/mocqkHhF++Z+69f+4ceWtybqj2ouMLXKnf3oBR+KcZ3K83oiaQsfLv/eJYVDtR0FDZujHpJhEEhxUKlVIE1IDVXFzFhYeX1KrIaa6x2mhySd1t+9I3Kyn+0xpvPXb5OKbOzNzTtYlE0I5tzZxrz9YIMQcDOYRWQ/nTw0nLVx9z/8Ogl134BuuqMbFRrt3PvnUuK/DUfxld/9d8yFWffWvBAOrDOeXC+/d06s7KZYsaFna2y7CouglApME4CTd0vaBzHx19f3PWdYDde8nqqbHcdIQPWPusvdFNY00KuT1/WpqaRsHkam5Nob/9+89Beg6Rzyc7XpFOQyrEIvu2kyv+ZRn/zLf3o9DKaKCDHgBLksxEZVT1WUnByuHM4oho7N3/pcQdqVXUbaPHWfTMCxtyhsl7lRPO7XKCFVRSME+bldrbgpblsPLEG5ThnOzMqp+GTCfeeVDH7OGKX2+NcMXs2eq7hpwX1QvKjr5Icq4wBGE75rIfKVogGau1kqs9Pqhm+ogSbkF72qRNPAAAAIEzB64P1lqXIlck0/6zfi+Jkr6+PQqxkOGOSV3VuJ1QnYsJDw6bb6qWka+U4yXXmorF5YV8rocs02q2LWUOQ6zTeO/voMf97D9OPzSdEjYWBzEwExYVk1LxdOD6QA0kPAGHa6N7cUMA3UKnx60Tj6JGnnQQYtttS/aAVFs2MfKAdA6lXqqZlVz8OuHHzDh6vyMe7bS/MnCe1Dx+JZQWNsW+5UvcT4hvrJ/k9emKtUnwrSUL0uzV51sBz+Qp9OrK6j1skGmbrUPPldjj2xjiGWk0S+Of7anEVXwRM67Y7QAXBpvVAQmA4QAHCwEAASMDAQEFXQAQAAAMgW8KARqVY08AAA==; VarID: ---
Type - Grafica - SymbolApiHeight: 0 m; SymbolScale: 1; SymbolApiLength: 0.0028 m; SymbolApiWidth: 0.00028 m; SymbolHeight: 0.0008 m; SymbolLength: 0.0028 m; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod.Q515
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod.Q515; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Altro - Famiglia: LFX_I_IguzziniMod.Q515: LFX_I_IguzziniMod.Q515; Famiglia e tipo: LFX_I_IguzziniMod.Q515: LFX_I_IguzziniMod.Q515; ID tipo: LFX_I_IguzziniMod.Q515: LFX_I_IguzziniMod.Q515; Tipo: LFX_I_IguzziniMod.Q515: LFX_I_IguzziniMod.Q515
Elettrico - Circuiti - Dati elettrici: 0 V/1-34 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Quota altimetrica da livello: 4 m
Name (LFX_I_IguzziniMod.Q515:LFX_I_IguzziniMod.Q515:...) | Contrassegno | Host
8869924 | 4932 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8870072 | 4941 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8870153 | 4968 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8870184 | 4977 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8870234 | 4995 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9415426 | 5054 | <non associato>
9453544 | 5285 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453546 | 5286 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453548 | 5287 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453550 | 5288 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453552 | 5289 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453564 | 5290 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453566 | 5291 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453568 | 5292 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453570 | 5293 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453572 | 5294 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453590 | 5295 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453592 | 5296 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453594 | 5297 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453596 | 5298 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453598 | 5299 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453609 | 5300 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453611 | 5301 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453613 | 5302 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453615 | 5303 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453617 | 5304 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453635 | 5305 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453637 | 5306 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453639 | 5307 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453641 | 5308 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453643 | 5309 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453654 | 5310 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453656 | 5311 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453658 | 5312 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453660 | 5313 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453662 | 5314 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9753164 | 6336 | <non associato>
9753184 | 6337 | <non associato>
9753200 | 6338 | <non associato>
9753203 | 6339 | <non associato>
9753206 | 6340 | <non associato>
9753222 | 6341 | <non associato>
9753224 | 6342 | <non associato>
9753226 | 6343 | <non associato>
9753239 | 6344 | <non associato>
9753241 | 6345 | <non associato>
9753243 | 6346 | <non associato>
9753274 | 6347 | <non associato>
9753276 | 6348 | <non associato>
9753278 | 6349 | <non associato>

# IfcLightFixture: LFX_I_IguzziniMod.QI23:LFX_I_IguzziniMod.QI23 (487)
Type - Material: Cover_Metal_Aluminium, Cover_White
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniMod.QI23
Type - Costruzione - Cover Width: 0.3 m
Type - Dati identità - Nome del tipo: LFX_I_IguzziniMod.QI23; Numero OmniClass: 23.80.70.11; Titolo OmniClass: Luminaries for Internal Lighting
Type - Dimensioni - Height: 0.038 m; Length: 0.6 m; Width: 0.6 m
Type - Elettrico - Commenti sul wattaggio: 1; Lampada: LED
Type - Elettrico - Carichi - Carico apparente: 50 W
Type - Materiali e finiture - Body: Cover_Metal_Aluminium; Cover: Cover_White
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod.QI23
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod.QI23; TotalWattage: 1 W
Altro - Famiglia: LFX_I_IguzziniMod.QI23: LFX_I_IguzziniMod.QI23; Famiglia e tipo: LFX_I_IguzziniMod.QI23: LFX_I_IguzziniMod.QI23; ID tipo: LFX_I_IguzziniMod.QI23: LFX_I_IguzziniMod.QI23; Tipo: LFX_I_IguzziniMod.QI23: LFX_I_IguzziniMod.QI23
Dimensioni - Volume: 0.00447587 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-50 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Name (LFX_I_IguzziniMod.QI23:LFX_I_IguzziniMod.QI23:...) | In | Contrassegno | Host | Livello = Livello abaco | Quota altimetrica da livello (m)
8658084 | L00 - Piano Terra Piazza ELETTRICO | 3839 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658101 | L00 - Piano Terra Piazza ELETTRICO | 3840 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658118 | L00 - Piano Terra Piazza ELETTRICO | 3841 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658161 | L00 - Piano Terra Piazza ELETTRICO | 3843 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658476 | L00 - Piano Terra Piazza ELETTRICO | 3849 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658484 | L00 - Piano Terra Piazza ELETTRICO | 3850 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658494 | L00 - Piano Terra Piazza ELETTRICO | 3851 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658545 | L00 - Piano Terra Piazza ELETTRICO | 3852 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658553 | L00 - Piano Terra Piazza ELETTRICO | 3853 | <non associato> | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658561 | L00 - Piano Terra Piazza ELETTRICO | 3854 | <non associato> | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8658614 | L00 - Piano Terra Piazza ELETTRICO | 3855 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8659105 | L00 - Piano Terra Piazza ELETTRICO | 3870 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8659116 | L00 - Piano Terra Piazza ELETTRICO | 3871 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8659171 | L00 - Piano Terra Piazza ELETTRICO | 3872 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8659181 | L00 - Piano Terra Piazza ELETTRICO | 3873 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8659189 | L00 - Piano Terra Piazza ELETTRICO | 3874 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8659197 | L00 - Piano Terra Piazza ELETTRICO | 3875 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8659229 | L00 - Piano Terra Piazza ELETTRICO | 3878 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8665135 | L00 - Piano Terra Piazza ELETTRICO | 3900 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8665144 | L00 - Piano Terra Piazza ELETTRICO | 3901 | <non associato> | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8665155 | L00 - Piano Terra Piazza ELETTRICO | 3902 | <non associato> | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8665164 | L00 - Piano Terra Piazza ELETTRICO | 3903 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666263 | L00 - Piano Terra Piazza ELETTRICO | 3951 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666280 | L00 - Piano Terra Piazza ELETTRICO | 3952 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666314 | L00 - Piano Terra Piazza ELETTRICO | 3953 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666334 | L00 - Piano Terra Piazza ELETTRICO | 3954 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666344 | L00 - Piano Terra Piazza ELETTRICO | 3955 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666354 | L00 - Piano Terra Piazza ELETTRICO | 3956 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666418 | L00 - Piano Terra Piazza ELETTRICO | 3957 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666430 | L00 - Piano Terra Piazza ELETTRICO | 3958 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666440 | L00 - Piano Terra Piazza ELETTRICO | 3959 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666448 | L00 - Piano Terra Piazza ELETTRICO | 3960 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666456 | L00 - Piano Terra Piazza ELETTRICO | 3961 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666466 | L00 - Piano Terra Piazza ELETTRICO | 3962 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666474 | L00 - Piano Terra Piazza ELETTRICO | 3963 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666482 | L00 - Piano Terra Piazza ELETTRICO | 3964 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666490 | L00 - Piano Terra Piazza ELETTRICO | 3965 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666500 | L00 - Piano Terra Piazza ELETTRICO | 3966 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666510 | L00 - Piano Terra Piazza ELETTRICO | 3967 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666520 | L00 - Piano Terra Piazza ELETTRICO | 3968 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666530 | L00 - Piano Terra Piazza ELETTRICO | 3969 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666540 | L00 - Piano Terra Piazza ELETTRICO | 3970 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666550 | L00 - Piano Terra Piazza ELETTRICO | 3971 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666562 | L00 - Piano Terra Piazza ELETTRICO | 3972 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666570 | L00 - Piano Terra Piazza ELETTRICO | 3973 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666582 | L00 - Piano Terra Piazza ELETTRICO | 3974 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666590 | L00 - Piano Terra Piazza ELETTRICO | 3975 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666781 | L00 - Piano Terra Piazza ELETTRICO | 3976 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666789 | L00 - Piano Terra Piazza ELETTRICO | 3977 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666803 | L00 - Piano Terra Piazza ELETTRICO | 3978 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666813 | L00 - Piano Terra Piazza ELETTRICO | 3979 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666845 | L00 - Piano Terra Piazza ELETTRICO | 3982 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666942 | L00 - Piano Terra Piazza ELETTRICO | 3983 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8666943 | L00 - Piano Terra Piazza ELETTRICO | 3984 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673372 | L00 - Piano Terra Piazza ELETTRICO | 4026 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673407 | L00 - Piano Terra Piazza ELETTRICO | 4027 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673417 | L00 - Piano Terra Piazza ELETTRICO | 4028 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673429 | L00 - Piano Terra Piazza ELETTRICO | 4029 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673439 | L00 - Piano Terra Piazza ELETTRICO | 4030 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673447 | L00 - Piano Terra Piazza ELETTRICO | 4031 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673457 | L00 - Piano Terra Piazza ELETTRICO | 4032 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673471 | L00 - Piano Terra Piazza ELETTRICO | 4033 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
8673764 | L00 - Piano Terra Piazza ELETTRICO | 4054 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673812 | L00 - Piano Terra Piazza ELETTRICO | 4055 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673820 | L00 - Piano Terra Piazza ELETTRICO | 4056 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673828 | L00 - Piano Terra Piazza ELETTRICO | 4057 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673836 | L00 - Piano Terra Piazza ELETTRICO | 4058 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673844 | L00 - Piano Terra Piazza ELETTRICO | 4059 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673852 | L00 - Piano Terra Piazza ELETTRICO | 4060 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673860 | L00 - Piano Terra Piazza ELETTRICO | 4061 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673868 | L00 - Piano Terra Piazza ELETTRICO | 4062 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673876 | L00 - Piano Terra Piazza ELETTRICO | 4063 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673886 | L00 - Piano Terra Piazza ELETTRICO | 4064 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673894 | L00 - Piano Terra Piazza ELETTRICO | 4065 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673902 | L00 - Piano Terra Piazza ELETTRICO | 4066 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673910 | L00 - Piano Terra Piazza ELETTRICO | 4067 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673918 | L00 - Piano Terra Piazza ELETTRICO | 4068 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673928 | L00 - Piano Terra Piazza ELETTRICO | 4069 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673936 | L00 - Piano Terra Piazza ELETTRICO | 4070 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673946 | L00 - Piano Terra Piazza ELETTRICO | 4071 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673954 | L00 - Piano Terra Piazza ELETTRICO | 4072 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8673964 | L00 - Piano Terra Piazza ELETTRICO | 4073 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
8690361 | L00 - Piano Terra Piazza ELETTRICO | 4211 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690375 | L00 - Piano Terra Piazza ELETTRICO | 4212 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690386 | L00 - Piano Terra Piazza ELETTRICO | 4213 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690397 | L00 - Piano Terra Piazza ELETTRICO | 4214 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690408 | L00 - Piano Terra Piazza ELETTRICO | 4215 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690422 | L00 - Piano Terra Piazza ELETTRICO | 4216 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690433 | L00 - Piano Terra Piazza ELETTRICO | 4217 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690444 | L00 - Piano Terra Piazza ELETTRICO | 4218 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690695 | L00 - Piano Terra Piazza ELETTRICO | 4221 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690709 | L00 - Piano Terra Piazza ELETTRICO | 4222 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690723 | L00 - Piano Terra Piazza ELETTRICO | 4223 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690737 | L00 - Piano Terra Piazza ELETTRICO | 4224 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690751 | L00 - Piano Terra Piazza ELETTRICO | 4225 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690765 | L00 - Piano Terra Piazza ELETTRICO | 4226 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690779 | L00 - Piano Terra Piazza ELETTRICO | 4227 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690793 | L00 - Piano Terra Piazza ELETTRICO | 4228 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690807 | L00 - Piano Terra Piazza ELETTRICO | 4229 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690821 | L00 - Piano Terra Piazza ELETTRICO | 4230 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690835 | L00 - Piano Terra Piazza ELETTRICO | 4231 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690857 | L00 - Piano Terra Piazza ELETTRICO | 4233 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690868 | L00 - Piano Terra Piazza ELETTRICO | 4234 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690879 | L00 - Piano Terra Piazza ELETTRICO | 4235 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690890 | L00 - Piano Terra Piazza ELETTRICO | 4236 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690901 | L00 - Piano Terra Piazza ELETTRICO | 4237 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690912 | L00 - Piano Terra Piazza ELETTRICO | 4238 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690926 | L00 - Piano Terra Piazza ELETTRICO | 4239 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690937 | L00 - Piano Terra Piazza ELETTRICO | 4240 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690948 | L00 - Piano Terra Piazza ELETTRICO | 4241 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690962 | L00 - Piano Terra Piazza ELETTRICO | 4242 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690973 | L00 - Piano Terra Piazza ELETTRICO | 4243 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8690984 | L00 - Piano Terra Piazza ELETTRICO | 4244 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691001 | L00 - Piano Terra Piazza ELETTRICO | 4245 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691012 | L00 - Piano Terra Piazza ELETTRICO | 4246 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691023 | L00 - Piano Terra Piazza ELETTRICO | 4247 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691048 | L00 - Piano Terra Piazza ELETTRICO | 4249 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691059 | L00 - Piano Terra Piazza ELETTRICO | 4250 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691090 | L00 - Piano Terra Piazza ELETTRICO | 4252 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691101 | L00 - Piano Terra Piazza ELETTRICO | 4253 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691118 | L00 - Piano Terra Piazza ELETTRICO | 4254 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691129 | L00 - Piano Terra Piazza ELETTRICO | 4255 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691140 | L00 - Piano Terra Piazza ELETTRICO | 4256 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691154 | L00 - Piano Terra Piazza ELETTRICO | 4257 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691165 | L00 - Piano Terra Piazza ELETTRICO | 4258 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691176 | L00 - Piano Terra Piazza ELETTRICO | 4259 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691196 | L00 - Piano Terra Piazza ELETTRICO | 4260 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691207 | L00 - Piano Terra Piazza ELETTRICO | 4261 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691218 | L00 - Piano Terra Piazza ELETTRICO | 4262 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691238 | L00 - Piano Terra Piazza ELETTRICO | 4263 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691249 | L00 - Piano Terra Piazza ELETTRICO | 4264 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691260 | L00 - Piano Terra Piazza ELETTRICO | 4265 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691277 | L00 - Piano Terra Piazza ELETTRICO | 4266 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691288 | L00 - Piano Terra Piazza ELETTRICO | 4267 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691299 | L00 - Piano Terra Piazza ELETTRICO | 4268 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691632 | L00 - Piano Terra Piazza ELETTRICO | 4269 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691643 | L00 - Piano Terra Piazza ELETTRICO | 4270 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691657 | L00 - Piano Terra Piazza ELETTRICO | 4271 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691668 | L00 - Piano Terra Piazza ELETTRICO | 4272 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691717 | L00 - Piano Terra Piazza ELETTRICO | 4273 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691728 | L00 - Piano Terra Piazza ELETTRICO | 4274 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691739 | L00 - Piano Terra Piazza ELETTRICO | 4275 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691750 | L00 - Piano Terra Piazza ELETTRICO | 4276 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691770 | L00 - Piano Terra Piazza ELETTRICO | 4277 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691781 | L00 - Piano Terra Piazza ELETTRICO | 4278 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691792 | L00 - Piano Terra Piazza ELETTRICO | 4279 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691803 | L00 - Piano Terra Piazza ELETTRICO | 4280 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691814 | L00 - Piano Terra Piazza ELETTRICO | 4281 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8691825 | L00 - Piano Terra Piazza ELETTRICO | 4282 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692109 | L00 - Piano Terra Piazza ELETTRICO | 4286 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692126 | L00 - Piano Terra Piazza ELETTRICO | 4287 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
