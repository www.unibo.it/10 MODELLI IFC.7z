Properties of the parts of a building model (IFC4), part 16 of 23

# IfcLightFixture: LFX_I_IguzziniMod.QI23:LFX_I_IguzziniMod.QI23 (487)
Name (LFX_I_IguzziniMod.QI23:LFX_I_IguzziniMod.QI23:...) | In | Contrassegno | Host | Livello = Livello abaco | Quota altimetrica da livello (m)
8692178 | L00 - Piano Terra Piazza ELETTRICO | 4289 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
8692244 | L00 - Piano Terra Piazza ELETTRICO | 4291 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692252 | L00 - Piano Terra Piazza ELETTRICO | 4292 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692260 | L00 - Piano Terra Piazza ELETTRICO | 4293 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692268 | L00 - Piano Terra Piazza ELETTRICO | 4294 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692278 | L00 - Piano Terra Piazza ELETTRICO | 4295 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692286 | L00 - Piano Terra Piazza ELETTRICO | 4296 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692294 | L00 - Piano Terra Piazza ELETTRICO | 4297 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692472 | L00 - Piano Terra Piazza ELETTRICO | 4306 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8692480 | L00 - Piano Terra Piazza ELETTRICO | 4307 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8692488 | L00 - Piano Terra Piazza ELETTRICO | 4308 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8692578 | L00 - Piano Terra Piazza ELETTRICO | 4310 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
8692854 | L00 - Piano Terra Piazza ELETTRICO | 4325 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692943 | L00 - Piano Terra Piazza ELETTRICO | 4330 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692952 | L00 - Piano Terra Piazza ELETTRICO | 4331 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
8692960 | L00 - Piano Terra Piazza ELETTRICO | 4332 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3
8693382 | L00 - Piano Terra Piazza ELETTRICO | 4352 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8693392 | L00 - Piano Terra Piazza ELETTRICO | 4353 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8693400 | L00 - Piano Terra Piazza ELETTRICO | 4354 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8693477 | L00 - Piano Terra Piazza ELETTRICO | 4355 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8693478 | L00 - Piano Terra Piazza ELETTRICO | 4356 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8693479 | L00 - Piano Terra Piazza ELETTRICO | 4357 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8693480 | L00 - Piano Terra Piazza ELETTRICO | 4358 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
8699849 | L00 - Piano Terra Piazza ELETTRICO | 4550 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
8700242 | L00 - Piano Terra Piazza ELETTRICO | 4581 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
8700433 | L00 - Piano Terra Piazza ELETTRICO | 4589 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
8700459 | L00 - Piano Terra Piazza ELETTRICO | 4591 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
8700468 | L00 - Piano Terra Piazza ELETTRICO | 4593 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
8700760 | L02 - Piano Secondo ELETTRICO | 4597 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700774 | L02 - Piano Secondo ELETTRICO | 4598 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700785 | L02 - Piano Secondo ELETTRICO | 4599 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700799 | L02 - Piano Secondo ELETTRICO | 4600 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700810 | L02 - Piano Secondo ELETTRICO | 4601 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700821 | L02 - Piano Secondo ELETTRICO | 4602 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700877 | L02 - Piano Secondo ELETTRICO | 4603 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700888 | L02 - Piano Secondo ELETTRICO | 4604 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700899 | L02 - Piano Secondo ELETTRICO | 4605 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700910 | L02 - Piano Secondo ELETTRICO | 4606 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700924 | L02 - Piano Secondo ELETTRICO | 4607 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700935 | L02 - Piano Secondo ELETTRICO | 4608 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700952 | L02 - Piano Secondo ELETTRICO | 4609 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700963 | L02 - Piano Secondo ELETTRICO | 4610 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700988 | L02 - Piano Secondo ELETTRICO | 4612 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8700999 | L02 - Piano Secondo ELETTRICO | 4613 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701021 | L02 - Piano Secondo ELETTRICO | 4615 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701032 | L02 - Piano Secondo ELETTRICO | 4616 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701090 | L02 - Piano Secondo ELETTRICO | 4617 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701101 | L02 - Piano Secondo ELETTRICO | 4618 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701137 | L02 - Piano Secondo ELETTRICO | 4621 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701148 | L02 - Piano Secondo ELETTRICO | 4622 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701164 | L02 - Piano Secondo ELETTRICO | 4623 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701175 | L02 - Piano Secondo ELETTRICO | 4624 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701186 | L02 - Piano Secondo ELETTRICO | 4625 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701197 | L02 - Piano Secondo ELETTRICO | 4626 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701208 | L02 - Piano Secondo ELETTRICO | 4627 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701219 | L02 - Piano Secondo ELETTRICO | 4628 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701248 | L02 - Piano Secondo ELETTRICO | 4629 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701259 | L02 - Piano Secondo ELETTRICO | 4630 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701270 | L02 - Piano Secondo ELETTRICO | 4631 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701281 | L02 - Piano Secondo ELETTRICO | 4632 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701295 | L02 - Piano Secondo ELETTRICO | 4633 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701306 | L02 - Piano Secondo ELETTRICO | 4634 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701317 | L02 - Piano Secondo ELETTRICO | 4635 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701328 | L02 - Piano Secondo ELETTRICO | 4636 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701351 | L02 - Piano Secondo ELETTRICO | 4637 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701362 | L02 - Piano Secondo ELETTRICO | 4638 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701373 | L02 - Piano Secondo ELETTRICO | 4639 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701384 | L02 - Piano Secondo ELETTRICO | 4640 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701401 | L02 - Piano Secondo ELETTRICO | 4641 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701412 | L02 - Piano Secondo ELETTRICO | 4642 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701423 | L02 - Piano Secondo ELETTRICO | 4643 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701434 | L02 - Piano Secondo ELETTRICO | 4644 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701448 | L02 - Piano Secondo ELETTRICO | 4645 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701470 | L02 - Piano Secondo ELETTRICO | 4647 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701501 | L02 - Piano Secondo ELETTRICO | 4649 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701512 | L02 - Piano Secondo ELETTRICO | 4650 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701523 | L02 - Piano Secondo ELETTRICO | 4651 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701534 | L02 - Piano Secondo ELETTRICO | 4652 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701548 | L02 - Piano Secondo ELETTRICO | 4653 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701559 | L02 - Piano Secondo ELETTRICO | 4654 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701570 | L02 - Piano Secondo ELETTRICO | 4655 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701581 | L02 - Piano Secondo ELETTRICO | 4656 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701595 | L02 - Piano Secondo ELETTRICO | 4657 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701606 | L02 - Piano Secondo ELETTRICO | 4658 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701617 | L02 - Piano Secondo ELETTRICO | 4659 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701631 | L02 - Piano Secondo ELETTRICO | 4660 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701669 | L02 - Piano Secondo ELETTRICO | 4661 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701680 | L02 - Piano Secondo ELETTRICO | 4662 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701694 | L02 - Piano Secondo ELETTRICO | 4663 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701705 | L02 - Piano Secondo ELETTRICO | 4664 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701719 | L02 - Piano Secondo ELETTRICO | 4665 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701730 | L02 - Piano Secondo ELETTRICO | 4666 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701741 | L02 - Piano Secondo ELETTRICO | 4667 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701752 | L02 - Piano Secondo ELETTRICO | 4668 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701769 | L02 - Piano Secondo ELETTRICO | 4669 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701780 | L02 - Piano Secondo ELETTRICO | 4670 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701791 | L02 - Piano Secondo ELETTRICO | 4671 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701802 | L02 - Piano Secondo ELETTRICO | 4672 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701831 | L02 - Piano Secondo ELETTRICO | 4673 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701842 | L02 - Piano Secondo ELETTRICO | 4674 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701853 | L02 - Piano Secondo ELETTRICO | 4675 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701867 | L02 - Piano Secondo ELETTRICO | 4676 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701887 | L02 - Piano Secondo ELETTRICO | 4677 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701898 | L02 - Piano Secondo ELETTRICO | 4678 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701909 | L02 - Piano Secondo ELETTRICO | 4679 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701920 | L02 - Piano Secondo ELETTRICO | 4680 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701958 | L02 - Piano Secondo ELETTRICO | 4681 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701969 | L02 - Piano Secondo ELETTRICO | 4682 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701980 | L02 - Piano Secondo ELETTRICO | 4683 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8701991 | L02 - Piano Secondo ELETTRICO | 4684 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8702099 | L02 - Piano Secondo ELETTRICO | 4685 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8702100 | L02 - Piano Secondo ELETTRICO | 4686 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8702101 | L02 - Piano Secondo ELETTRICO | 4687 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703149 | L02 - Piano Secondo ELETTRICO | 4688 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703160 | L02 - Piano Secondo ELETTRICO | 4689 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703171 | L02 - Piano Secondo ELETTRICO | 4690 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703182 | L02 - Piano Secondo ELETTRICO | 4691 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703193 | L02 - Piano Secondo ELETTRICO | 4692 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703204 | L02 - Piano Secondo ELETTRICO | 4693 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703215 | L02 - Piano Secondo ELETTRICO | 4694 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703226 | L02 - Piano Secondo ELETTRICO | 4695 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703240 | L02 - Piano Secondo ELETTRICO | 4696 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703279 | L02 - Piano Secondo ELETTRICO | 4697 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703290 | L02 - Piano Secondo ELETTRICO | 4698 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703301 | L02 - Piano Secondo ELETTRICO | 4699 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703312 | L02 - Piano Secondo ELETTRICO | 4700 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703329 | L02 - Piano Secondo ELETTRICO | 4701 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703363 | L02 - Piano Secondo ELETTRICO | 4702 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703374 | L02 - Piano Secondo ELETTRICO | 4703 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703385 | L02 - Piano Secondo ELETTRICO | 4704 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703396 | L02 - Piano Secondo ELETTRICO | 4705 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703410 | L02 - Piano Secondo ELETTRICO | 4706 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703421 | L02 - Piano Secondo ELETTRICO | 4707 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703432 | L02 - Piano Secondo ELETTRICO | 4708 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703443 | L02 - Piano Secondo ELETTRICO | 4709 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703457 | L02 - Piano Secondo ELETTRICO | 4710 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703468 | L02 - Piano Secondo ELETTRICO | 4711 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703479 | L02 - Piano Secondo ELETTRICO | 4712 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703490 | L02 - Piano Secondo ELETTRICO | 4713 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703516 | L02 - Piano Secondo ELETTRICO | 4714 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703527 | L02 - Piano Secondo ELETTRICO | 4715 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703538 | L02 - Piano Secondo ELETTRICO | 4716 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703549 | L02 - Piano Secondo ELETTRICO | 4717 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703563 | L02 - Piano Secondo ELETTRICO | 4718 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703574 | L02 - Piano Secondo ELETTRICO | 4719 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703585 | L02 - Piano Secondo ELETTRICO | 4720 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703596 | L02 - Piano Secondo ELETTRICO | 4721 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703628 | L02 - Piano Secondo ELETTRICO | 4722 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703650 | L02 - Piano Secondo ELETTRICO | 4724 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703661 | L02 - Piano Secondo ELETTRICO | 4725 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703672 | L02 - Piano Secondo ELETTRICO | 4726 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703683 | L02 - Piano Secondo ELETTRICO | 4727 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703694 | L02 - Piano Secondo ELETTRICO | 4728 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703705 | L02 - Piano Secondo ELETTRICO | 4729 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703725 | L02 - Piano Secondo ELETTRICO | 4730 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703736 | L02 - Piano Secondo ELETTRICO | 4731 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703747 | L02 - Piano Secondo ELETTRICO | 4732 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703758 | L02 - Piano Secondo ELETTRICO | 4733 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703769 | L02 - Piano Secondo ELETTRICO | 4734 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703780 | L02 - Piano Secondo ELETTRICO | 4735 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703791 | L02 - Piano Secondo ELETTRICO | 4736 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703802 | L02 - Piano Secondo ELETTRICO | 4737 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703825 | L02 - Piano Secondo ELETTRICO | 4738 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703836 | L02 - Piano Secondo ELETTRICO | 4739 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703847 | L02 - Piano Secondo ELETTRICO | 4740 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703858 | L02 - Piano Secondo ELETTRICO | 4741 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703869 | L02 - Piano Secondo ELETTRICO | 4742 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703880 | L02 - Piano Secondo ELETTRICO | 4743 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703894 | L02 - Piano Secondo ELETTRICO | 4744 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703905 | L02 - Piano Secondo ELETTRICO | 4745 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703916 | L02 - Piano Secondo ELETTRICO | 4746 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703930 | L02 - Piano Secondo ELETTRICO | 4747 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703941 | L02 - Piano Secondo ELETTRICO | 4748 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703952 | L02 - Piano Secondo ELETTRICO | 4749 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703966 | L02 - Piano Secondo ELETTRICO | 4750 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703977 | L02 - Piano Secondo ELETTRICO | 4751 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703988 | L02 - Piano Secondo ELETTRICO | 4752 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8703999 | L02 - Piano Secondo ELETTRICO | 4753 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704010 | L02 - Piano Secondo ELETTRICO | 4754 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704021 | L02 - Piano Secondo ELETTRICO | 4755 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704035 | L02 - Piano Secondo ELETTRICO | 4756 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704046 | L02 - Piano Secondo ELETTRICO | 4757 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704057 | L02 - Piano Secondo ELETTRICO | 4758 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704068 | L02 - Piano Secondo ELETTRICO | 4759 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704079 | L02 - Piano Secondo ELETTRICO | 4760 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8704090 | L02 - Piano Secondo ELETTRICO | 4761 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8705543 | L02 - Piano Secondo ELETTRICO | 4791 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
8705544 | L02 - Piano Secondo ELETTRICO | 4792 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9429785 | L00 - Piano Terra Piazza ELETTRICO | 5065 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9429796 | L00 - Piano Terra Piazza ELETTRICO | 5066 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9429875 | L00 - Piano Terra Piazza ELETTRICO | 5067 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9429889 | L00 - Piano Terra Piazza ELETTRICO | 5068 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9438447 | L02 - Piano Secondo ELETTRICO | 5109 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9438448 | L02 - Piano Secondo ELETTRICO | 5110 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9438543 | L02 - Piano Secondo ELETTRICO | 5111 | <non associato> | Livello: L02 - Piano Secondo ELETTRICO | 3
9438544 | L02 - Piano Secondo ELETTRICO | 5112 | <non associato> | Livello: L02 - Piano Secondo ELETTRICO | 3
9438545 | L02 - Piano Secondo ELETTRICO | 5113 | <non associato> | Livello: L02 - Piano Secondo ELETTRICO | 3
9438546 | L02 - Piano Secondo ELETTRICO | 5114 | <non associato> | Livello: L02 - Piano Secondo ELETTRICO | 3
9438547 | L02 - Piano Secondo ELETTRICO | 5115 | <non associato> | Livello: L02 - Piano Secondo ELETTRICO | 3
9438548 | L02 - Piano Secondo ELETTRICO | 5116 | <non associato> | Livello: L02 - Piano Secondo ELETTRICO | 3
9439990 | L02 - Piano Secondo ELETTRICO | 5130 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9439991 | L02 - Piano Secondo ELETTRICO | 5131 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9440073 | L02 - Piano Secondo ELETTRICO | 5132 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9440144 | L02 - Piano Secondo ELETTRICO | 5133 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9440145 | L02 - Piano Secondo ELETTRICO | 5134 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9440282 | L02 - Piano Secondo ELETTRICO | 5135 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9440283 | L02 - Piano Secondo ELETTRICO | 5136 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9440486 | L02 - Piano Secondo ELETTRICO | 5137 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L02 - Piano Secondo ELETTRICO | 3
9441363 | L00 - Piano Terra Piazza ELETTRICO | 5141 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9441681 | L00 - Piano Terra Piazza ELETTRICO | 5142 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9441682 | L00 - Piano Terra Piazza ELETTRICO | 5143 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9441719 | L00 - Piano Terra Piazza ELETTRICO | 5144 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9441739 | L00 - Piano Terra Piazza ELETTRICO | 5145 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9441862 | L00 - Piano Terra Piazza ELETTRICO | 5146 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9442749 | L00 - Piano Terra Piazza ELETTRICO | 5167 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442750 | L00 - Piano Terra Piazza ELETTRICO | 5168 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442751 | L00 - Piano Terra Piazza ELETTRICO | 5169 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442752 | L00 - Piano Terra Piazza ELETTRICO | 5170 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442792 | L00 - Piano Terra Piazza ELETTRICO | 5171 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442793 | L00 - Piano Terra Piazza ELETTRICO | 5172 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442794 | L00 - Piano Terra Piazza ELETTRICO | 5173 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442795 | L00 - Piano Terra Piazza ELETTRICO | 5174 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442837 | L00 - Piano Terra Piazza ELETTRICO | 5175 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442857 | L00 - Piano Terra Piazza ELETTRICO | 5176 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442882 | L00 - Piano Terra Piazza ELETTRICO | 5177 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442903 | L00 - Piano Terra Piazza ELETTRICO | 5178 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442905 | L00 - Piano Terra Piazza ELETTRICO | 5179 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442907 | L00 - Piano Terra Piazza ELETTRICO | 5180 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9442908 | L00 - Piano Terra Piazza ELETTRICO | 5181 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443129 | L00 - Piano Terra Piazza ELETTRICO | 5182 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443130 | L00 - Piano Terra Piazza ELETTRICO | 5183 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443131 | L00 - Piano Terra Piazza ELETTRICO | 5184 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443132 | L00 - Piano Terra Piazza ELETTRICO | 5185 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3
9443148 | L00 - Piano Terra Piazza ELETTRICO | 5186 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443149 | L00 - Piano Terra Piazza ELETTRICO | 5187 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443150 | L00 - Piano Terra Piazza ELETTRICO | 5188 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443151 | L00 - Piano Terra Piazza ELETTRICO | 5189 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3
9443163 | L00 - Piano Terra Piazza ELETTRICO | 5190 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443164 | L00 - Piano Terra Piazza ELETTRICO | 5191 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443165 | L00 - Piano Terra Piazza ELETTRICO | 5192 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443166 | L00 - Piano Terra Piazza ELETTRICO | 5193 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3
9443182 | L00 - Piano Terra Piazza ELETTRICO | 5194 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443183 | L00 - Piano Terra Piazza ELETTRICO | 5195 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443184 | L00 - Piano Terra Piazza ELETTRICO | 5196 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443185 | L00 - Piano Terra Piazza ELETTRICO | 5197 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3
9443202 | L00 - Piano Terra Piazza ELETTRICO | 5198 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443203 | L00 - Piano Terra Piazza ELETTRICO | 5199 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443204 | L00 - Piano Terra Piazza ELETTRICO | 5200 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3
9443205 | L00 - Piano Terra Piazza ELETTRICO | 5201 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3
9443568 | L00 - Piano Terra Piazza ELETTRICO | 5207 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443569 | L00 - Piano Terra Piazza ELETTRICO | 5208 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443570 | L00 - Piano Terra Piazza ELETTRICO | 5209 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443571 | L00 - Piano Terra Piazza ELETTRICO | 5210 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443633 | L00 - Piano Terra Piazza ELETTRICO | 5215 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443634 | L00 - Piano Terra Piazza ELETTRICO | 5216 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443635 | L00 - Piano Terra Piazza ELETTRICO | 5217 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443636 | L00 - Piano Terra Piazza ELETTRICO | 5218 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443649 | L00 - Piano Terra Piazza ELETTRICO | 5219 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443650 | L00 - Piano Terra Piazza ELETTRICO | 5220 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443651 | L00 - Piano Terra Piazza ELETTRICO | 5221 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443652 | L00 - Piano Terra Piazza ELETTRICO | 5222 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9443739 | L00 - Piano Terra Piazza ELETTRICO | 5223 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443740 | L00 - Piano Terra Piazza ELETTRICO | 5224 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443741 | L00 - Piano Terra Piazza ELETTRICO | 5225 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443742 | L00 - Piano Terra Piazza ELETTRICO | 5226 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443751 | L00 - Piano Terra Piazza ELETTRICO | 5231 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443752 | L00 - Piano Terra Piazza ELETTRICO | 5232 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443753 | L00 - Piano Terra Piazza ELETTRICO | 5233 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443754 | L00 - Piano Terra Piazza ELETTRICO | 5234 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443755 | L00 - Piano Terra Piazza ELETTRICO | 5235 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443756 | L00 - Piano Terra Piazza ELETTRICO | 5236 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443757 | L00 - Piano Terra Piazza ELETTRICO | 5237 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443758 | L00 - Piano Terra Piazza ELETTRICO | 5238 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443760 | L00 - Piano Terra Piazza ELETTRICO | 5239 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443761 | L00 - Piano Terra Piazza ELETTRICO | 5240 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443762 | L00 - Piano Terra Piazza ELETTRICO | 5241 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9443763 | L00 - Piano Terra Piazza ELETTRICO | 5242 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9454716 | L00 - Piano Terra Piazza ELETTRICO | 5336 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9454747 | L00 - Piano Terra Piazza ELETTRICO | 5337 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9454775 | L00 - Piano Terra Piazza ELETTRICO | 5339 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9454776 | L00 - Piano Terra Piazza ELETTRICO | 5340 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9454777 | L00 - Piano Terra Piazza ELETTRICO | 5341 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9454778 | L00 - Piano Terra Piazza ELETTRICO | 5342 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9454839 | L00 - Piano Terra Piazza ELETTRICO | 5344 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455084 | L00 - Piano Terra Piazza ELETTRICO | 5345 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455117 | L00 - Piano Terra Piazza ELETTRICO | 5346 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455118 | L00 - Piano Terra Piazza ELETTRICO | 5347 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455119 | L00 - Piano Terra Piazza ELETTRICO | 5348 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455120 | L00 - Piano Terra Piazza ELETTRICO | 5349 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455121 | L00 - Piano Terra Piazza ELETTRICO | 5350 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455123 | L00 - Piano Terra Piazza ELETTRICO | 5351 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455142 | L00 - Piano Terra Piazza ELETTRICO | 5352 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455143 | L00 - Piano Terra Piazza ELETTRICO | 5353 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455144 | L00 - Piano Terra Piazza ELETTRICO | 5354 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455145 | L00 - Piano Terra Piazza ELETTRICO | 5355 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455149 | L00 - Piano Terra Piazza ELETTRICO | 5356 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455150 | L00 - Piano Terra Piazza ELETTRICO | 5357 | <non associato> | Livello: L01 - Piano Primo ELETTRICO | 3.2
9455394 | L00 - Piano Terra Piazza ELETTRICO | 5358 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455419 | L00 - Piano Terra Piazza ELETTRICO | 5359 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455420 | L00 - Piano Terra Piazza ELETTRICO | 5360 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455455 | L00 - Piano Terra Piazza ELETTRICO | 5361 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455495 | L00 - Piano Terra Piazza ELETTRICO | 5362 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455551 | L00 - Piano Terra Piazza ELETTRICO | 5363 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455552 | L00 - Piano Terra Piazza ELETTRICO | 5364 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455554 | L00 - Piano Terra Piazza ELETTRICO | 5365 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455555 | L00 - Piano Terra Piazza ELETTRICO | 5366 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455556 | L00 - Piano Terra Piazza ELETTRICO | 5367 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455557 | L00 - Piano Terra Piazza ELETTRICO | 5368 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455583 | L00 - Piano Terra Piazza ELETTRICO | 5369 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455584 | L00 - Piano Terra Piazza ELETTRICO | 5370 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455585 | L00 - Piano Terra Piazza ELETTRICO | 5371 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455586 | L00 - Piano Terra Piazza ELETTRICO | 5372 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455587 | L00 - Piano Terra Piazza ELETTRICO | 5373 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455588 | L00 - Piano Terra Piazza ELETTRICO | 5374 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455694 | L00 - Piano Terra Piazza ELETTRICO | 5375 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455695 | L00 - Piano Terra Piazza ELETTRICO | 5376 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455696 | L00 - Piano Terra Piazza ELETTRICO | 5377 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455697 | L00 - Piano Terra Piazza ELETTRICO | 5378 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455698 | L00 - Piano Terra Piazza ELETTRICO | 5379 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455699 | L00 - Piano Terra Piazza ELETTRICO | 5380 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455719 | L00 - Piano Terra Piazza ELETTRICO | 5381 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455720 | L00 - Piano Terra Piazza ELETTRICO | 5382 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455721 | L00 - Piano Terra Piazza ELETTRICO | 5383 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455722 | L00 - Piano Terra Piazza ELETTRICO | 5384 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455723 | L00 - Piano Terra Piazza ELETTRICO | 5385 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455724 | L00 - Piano Terra Piazza ELETTRICO | 5386 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455742 | L00 - Piano Terra Piazza ELETTRICO | 5387 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455743 | L00 - Piano Terra Piazza ELETTRICO | 5388 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455744 | L00 - Piano Terra Piazza ELETTRICO | 5389 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455745 | L00 - Piano Terra Piazza ELETTRICO | 5390 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455746 | L00 - Piano Terra Piazza ELETTRICO | 5391 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9455747 | L00 - Piano Terra Piazza ELETTRICO | 5392 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 4
9698852 | L00 - Piano Terra Piazza ELETTRICO | 6157 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9698853 | L00 - Piano Terra Piazza ELETTRICO | 6203 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9698854 | L00 - Piano Terra Piazza ELETTRICO | 6204 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5
9698855 | L00 - Piano Terra Piazza ELETTRICO | 6205 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Livello: L01 - Piano Primo ELETTRICO | 3.5

# IfcLightFixture: LFX_I_IguzziniMod.Qu47:LFX_I_IguzziniMod.Qu47 (62)
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniMod.Qu47
Type - Costruzione - CFG_: ---_0001; Mounting Place: Ceiling; Mounting Type: Surface mounted
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: QU53 : A round luminaire that can be surface or pendant-mounted using a kit to be ordered separately. The product is designed to use LED lamps with C.o.B. technology. Reflector vacuum-metallised with aluminium vapours with an anti-scratch protective layer. The product is fitted with a passive dissipation system. Luminaire complete with LED lamp in warm white colour tone (3000K). General lighting beam. Product complete with inverter, in case of a blackout, operation is guaranteed for a maximum of 3 hours. QU53.39 - Ø 212 mm - warm white - inverter - 23W 3500lm - 3000K - White/Aluminium C06L - Lamp LED Warm White CRI>80; Modello: QU53; Nome del tipo: LFX_I_IguzziniMod.Qu47; Product group: ceiling mounted luminaire; Product Name: Easy; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___qu53/
Type - Dimensioni - Width: 0 m; Height: 0.205 m; Length: 0.234 m; Weight: 0 kg
Type - Elettrico - Number of Poles: 1; Commenti sul wattaggio: 1; Lampada: 1 x LED; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 31.2 W; Voltage: 0 V
Type - Elettrico - Carichi - Power Factor: 1; Carico apparente: 31.2 W
Type - Elettrico - Illuminazione - Luminous efficacy: 100.962 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 79 99 100 100 90; Color Rendering: 80; Color Temperature: 3000K; Lamp count: 1; Lamp Light Flux: 3500 lm; Lifetime: 100000 h; Socket: socket; System Light Flux: 3150 lm
