Properties of the parts of a building model (IFC4), part 6 of 23

# IfcBuildingElementProxy: Contatto magnetico porte allarmate:DSE_I_ContattoMagneticoPorteAllarmate (57)
Name (Contatto magnetico porte allarmate:DSE_I_ContattoMagneticoPorteAllarmate:...) | In | Contrassegno | Livello = Livello abaco | Quota altimetrica da livello (m)
9615914 | L00 - Piano Terra Piazza ELETTRICO | 370 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.22237
9616161 | L00 - Piano Terra Piazza ELETTRICO | 371 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.22077
9616233 | L00 - Piano Terra Piazza ELETTRICO | 372 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.2256
9616343 | L00 - Piano Terra Piazza ELETTRICO | 373 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.22747
9616672 | L00 - Piano Terra Piazza ELETTRICO | 374 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.13701
9616708 | L00 - Piano Terra Piazza ELETTRICO | 375 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.22214
9616834 | L00 - Piano Terra Piazza ELETTRICO | 376 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.21593
9616943 | L00 - Piano Terra Piazza ELETTRICO | 377 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.13282
9659167 | B01 - Piano Interrato ELETTRICO | 378 | Livello: B01 - Piano Interrato ELETTRICO | 3.29991
9659169 | B01 - Piano Interrato ELETTRICO | 379 | Livello: B01 - Piano Interrato ELETTRICO | 3.29661
9659176 | B01 - Piano Interrato ELETTRICO | 380 | Livello: B01 - Piano Interrato ELETTRICO | 2.48749
9659178 | B01 - Piano Interrato ELETTRICO | 381 | Livello: B01 - Piano Interrato ELETTRICO | 1.85614
9659184 | B01 - Piano Interrato ELETTRICO | 384 | Livello: B01 - Piano Interrato ELETTRICO | 1.83658
9659186 | B01 - Piano Interrato ELETTRICO | 385 | Livello: B01 - Piano Interrato ELETTRICO | 1.90047
9659188 | L00 - Piano Terra Piazza ELETTRICO | 386 | Livello: L01 - Piano Primo ELETTRICO | 2.05866
9659191 | L02 - Piano Secondo ELETTRICO | 387 | Livello: L02 - Piano Secondo ELETTRICO | 2.12578
9659193 | L00 - Piano Terra Piazza ELETTRICO | 388 | Livello: L01 - Piano Primo ELETTRICO | 2.2435
9659197 | L02 - Piano Secondo ELETTRICO | 390 | Livello: L02 - Piano Secondo ELETTRICO | 2.13641
9659199 | L02 - Piano Secondo ELETTRICO | 391 | Livello: L02 - Piano Secondo ELETTRICO | 2.13369
10344438 | B01 - Piano Interrato ELETTRICO | 493 | Livello: B01 - Piano Interrato ELETTRICO | 2.19094
10344444 | B01 - Piano Interrato ELETTRICO | 495 | Livello: B01 - Piano Interrato ELETTRICO | 2.18434
10344446 | B01 - Piano Interrato ELETTRICO | 496 | Livello: B01 - Piano Interrato ELETTRICO | 2.1859
10344448 | B01 - Piano Interrato ELETTRICO | 498 | Livello: B01 - Piano Interrato ELETTRICO | 2.18183
10344449 | B01 - Piano Interrato ELETTRICO | 499 | Livello: B01 - Piano Interrato ELETTRICO | 2.18256
10344456 | L00 - Piano Terra Piazza ELETTRICO | 503 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.18037
10344458 | L00 - Piano Terra Piazza ELETTRICO | 505 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.19098
10344459 | L00 - Piano Terra Piazza ELETTRICO | 506 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.20344
10344461 | L00 - Piano Terra Piazza ELETTRICO | 507 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.19477
10344462 | L00 - Piano Terra Piazza ELETTRICO | 508 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.18126
10344464 | L00 - Piano Terra Piazza ELETTRICO | 509 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.18715
10344466 | L00 - Piano Terra Piazza ELETTRICO | 510 | Livello: L01 - Piano Primo ELETTRICO | 2.21793
10344468 | L00 - Piano Terra Piazza ELETTRICO | 511 | Livello: L01 - Piano Primo ELETTRICO | 2.21392
10344473 | L00 - Piano Terra Piazza ELETTRICO | 513 | Livello: L01 - Piano Primo ELETTRICO | 2.21154
10344476 | L00 - Piano Terra Piazza ELETTRICO | 516 | Livello: L01 - Piano Primo ELETTRICO | 2.19349
10344478 | L00 - Piano Terra Piazza ELETTRICO | 517 | Livello: L01 - Piano Primo ELETTRICO | 2.21913
10344480 | L00 - Piano Terra Piazza ELETTRICO | 518 | Livello: L01 - Piano Primo ELETTRICO | 2.18687
10344481 | L00 - Piano Terra Piazza ELETTRICO | 519 | Livello: L01 - Piano Primo ELETTRICO | 2.14441
10344483 | L00 - Piano Terra Piazza ELETTRICO | 520 | Livello: L01 - Piano Primo ELETTRICO | 2.19301
10344488 | L02 - Piano Secondo ELETTRICO | 524 | Livello: L02 - Piano Secondo ELETTRICO | 2.19484
10344489 | L02 - Piano Secondo ELETTRICO | 525 | Livello: L02 - Piano Secondo ELETTRICO | 2.18483
10344491 | B01 - Piano Interrato ELETTRICO | 527 | Livello: B01 - Piano Interrato ELETTRICO | 20.5456

# IfcBuildingElementProxy: Electronics -Communication_Urmet_KP500D-ST:EFX_I_TastieraDiComando (69)
Type - Classification: 80KP7600111 (Uniformat)
Type - Altro - Categoria: Apparecchi elettrici; Buzzer with adjustable volume: Yes; Certification: -; Contrast and brightness adjustment: yes; Display: OLED-technology graphic display; Inputs: 2 (auxiliary); Microphone, loudspeakers and audio connection: no; Nome famiglia: Electronics -Communication_Urmet_KP500D-ST; Number and type of keys: 12 alphanumerical keys, 7 navigation keys and 4 function keys; Powered by the BUS connecting to the control unit: yes; Protection against opening and removal: yes
Type - Dati - Additional led signalizations: 0; Humidity range (%): 75%; IK Grade: 06; Installation: Surface mounting; IP Grade: 40; Main led signalizations: 4; System technology: BUS line; Temperature range (°C): -10/40; Weight net: 0.2 kg
Type - Dati identità - Codice assieme: 80KP7600111; Combined Nomenclature Code: 8531900000; Commenti sul tipo: COMANDI; Contrassegno tipo: 1; Data-sheet:: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; Descrizione: TOUCH KEYPAD; EAN Product Code: 8034034446376; Installation instructions: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; Modello: KP500D-ST; Nome del tipo: EFX_I_TastieraDiComando; Product certification: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; Product Guide:: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; Product url: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; Produttore: Urmet S.p.A. Urmet S.p.A.; System name: MP500; Technical description: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; Type image: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; UE Conformity Declaration:: http://qrcode.urmet.com/default.aspx?sito=Elkron&prodElkron=145774&lingua=en; URL: https://www.urmet.com
Type - Dimensioni - Dimensions (LxHxP): 160 x 130 x 23.5 mm
Type - Elettrico - N. od terminal blocks: 7; Power consumption: 0,2 A maximum; Terminal block labels: -, D, +D, +, A1, A2, +IN; Voltage: Input: 13,8Vdc; Wiring: BUS line
Type - Generale - Edition number: 1; Brand url: https://www.urmet.com/en-us/; Date of publishing: 2020-12-23; Design country: Italy; Manufacturer country: Italy; Nominal height: 0.13 m; Nominal width: 0.16 m; Product SKU: KP500D-ST; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Sustainability Performance: RAEE/WEEE compliant
Type - Materiali e finiture - Color: White RAL9003; Finishing: Gloss; Material main: Cover: silked tempered Glass; bottom: plastic
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_TastieraDiComando
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_TastieraDiComando
Type - Pset_ManufacturerTypeInformation - Manufacturer: Urmet S.p.A. Urmet S.p.A.
Altro - Famiglia: Electronics -Communication_Urmet_KP500D-ST: EFX_I_TastieraDiComando; Famiglia e tipo: Electronics -Communication_Urmet_KP500D-ST: EFX_I_TastieraDiComando; ID tipo: Electronics -Communication_Urmet_KP500D-ST: EFX_I_TastieraDiComando; Tipo: Electronics -Communication_Urmet_KP500D-ST: EFX_I_TastieraDiComando
Fasi - Fase di creazione: Nuova costruzione
Name (Electronics -Communication_Urmet_KP500D-ST:EFX_I_TastieraDiComando:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
10382833 | L00 - Piano Terra Piazza ELETTRICO | 4817 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 1.3
10386577 | L00 - Piano Terra Piazza ELETTRICO | 4818 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10386604 | L00 - Piano Terra Piazza ELETTRICO | 4819 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 1.3
10389304 | L00 - Piano Terra Piazza ELETTRICO | 4820 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.3
10389330 | L00 - Piano Terra Piazza ELETTRICO | 4821 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10389618 | L00 - Piano Terra Piazza ELETTRICO | 4822 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10389647 | L00 - Piano Terra Piazza ELETTRICO | 4823 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10389711 | L00 - Piano Terra Piazza ELETTRICO | 4824 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10389757 | L00 - Piano Terra Piazza ELETTRICO | 4825 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390138 | L02 - Piano Secondo ELETTRICO | 4826 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.20102
10390194 | L02 - Piano Secondo ELETTRICO | 4827 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390227 | L02 - Piano Secondo ELETTRICO | 4828 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390266 | L02 - Piano Secondo ELETTRICO | 4829 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390299 | L02 - Piano Secondo ELETTRICO | 4830 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390337 | L02 - Piano Secondo ELETTRICO | 4831 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390409 | L02 - Piano Secondo ELETTRICO | 4832 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390448 | L02 - Piano Secondo ELETTRICO | 4833 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390511 | L02 - Piano Secondo ELETTRICO | 4834 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390589 | L02 - Piano Secondo ELETTRICO | 4835 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390652 | L02 - Piano Secondo ELETTRICO | 4836 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390691 | L02 - Piano Secondo ELETTRICO | 4837 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390752 | L02 - Piano Secondo ELETTRICO | 4838 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390818 | L02 - Piano Secondo ELETTRICO | 4839 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10390917 | L02 - Piano Secondo ELETTRICO | 4840 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391035 | L02 - Piano Secondo ELETTRICO | 4841 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391089 | L02 - Piano Secondo ELETTRICO | 4842 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391141 | L02 - Piano Secondo ELETTRICO | 4843 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391213 | L02 - Piano Secondo ELETTRICO | 4844 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391253 | L02 - Piano Secondo ELETTRICO | 4845 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391361 | L02 - Piano Secondo ELETTRICO | 4846 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391395 | L02 - Piano Secondo ELETTRICO | 4847 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391481 | L02 - Piano Secondo ELETTRICO | 4848 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391521 | L02 - Piano Secondo ELETTRICO | 4849 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391583 | L02 - Piano Secondo ELETTRICO | 4850 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391661 | L02 - Piano Secondo ELETTRICO | 4851 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391766 | L02 - Piano Secondo ELETTRICO | 4852 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391833 | L02 - Piano Secondo ELETTRICO | 4853 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10391891 | L02 - Piano Secondo ELETTRICO | 4854 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10392215 | L02 - Piano Secondo ELETTRICO | 4855 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10392244 | L02 - Piano Secondo ELETTRICO | 4856 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10392337 | L02 - Piano Secondo ELETTRICO | 4857 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10392400 | L02 - Piano Secondo ELETTRICO | 4858 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10392699 | L00 - Piano Terra Piazza ELETTRICO | 4859 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10392779 | L00 - Piano Terra Piazza ELETTRICO | 4860 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10392931 | L00 - Piano Terra Piazza ELETTRICO | 4861 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393014 | L00 - Piano Terra Piazza ELETTRICO | 4862 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393301 | L00 - Piano Terra Piazza ELETTRICO | 4863 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393439 | L00 - Piano Terra Piazza ELETTRICO | 4864 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393458 | L00 - Piano Terra Piazza ELETTRICO | 4865 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393533 | L00 - Piano Terra Piazza ELETTRICO | 4866 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393591 | L00 - Piano Terra Piazza ELETTRICO | 4867 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393662 | L00 - Piano Terra Piazza ELETTRICO | 4868 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393723 | L00 - Piano Terra Piazza ELETTRICO | 4869 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393919 | L00 - Piano Terra Piazza ELETTRICO | 4870 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393941 | L00 - Piano Terra Piazza ELETTRICO | 4871 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10393989 | L00 - Piano Terra Piazza ELETTRICO | 4872 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10394073 | L00 - Piano Terra Piazza ELETTRICO | 4873 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10394140 | L00 - Piano Terra Piazza ELETTRICO | 4874 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 1.3
10394218 | L00 - Piano Terra Piazza ELETTRICO | 4875 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10394348 | L00 - Piano Terra Piazza ELETTRICO | 4876 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10394466 | L00 - Piano Terra Piazza ELETTRICO | 4877 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10394505 | L00 - Piano Terra Piazza ELETTRICO | 4878 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10394759 | L00 - Piano Terra Piazza ELETTRICO | 4879 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10394891 | L00 - Piano Terra Piazza ELETTRICO | 4880 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10395123 | L00 - Piano Terra Piazza ELETTRICO | 4881 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10483087 | B01 - Piano Interrato ELETTRICO | 4978 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2192 | Dati identità - Commenti: Aula magna
10667724 | L00 - Piano Terra Piazza ELETTRICO | 5062 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
10667725 | L00 - Piano Terra Piazza ELETTRICO | 5063 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.3
10667727 | L00 - Piano Terra Piazza ELETTRICO | 5064 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3

# IfcBuildingElementProxy: Electronics _Audio_Speakers_Lowell_ESP-82TW:DCA_I_DiffusoriAPlafone(Scale) (12)
Type - Material: Plastic - Lowell - White, Steel - Lowell - White
Type - Altro - Categoria: Dispositivi di comunicazione; Nome famiglia: Electronics _Audio_Speakers_Lowell_ESP-82TW
Type - Dati identità - Commenti sul tipo: Audio Evac; Copyright: Copyright © 2021 Lowell Manufacturing; Descrizione: ESP-82TW: 8 inch Coaxial Pendant Speaker; Family Version: 1.0; Model Disclaimer: Contact Lowell Manufacturing for More Information; Modello: ESP-82TW; Nome del tipo: DCA_I_DiffusoriAPlafone(Scale); Numero OmniClass: 23.85.10.11.11.21; Product data url: https://www.bimobject.com/lowell/product/esp-82tw_8-inch-coaxial-pendant-speaker; Product Documentation Link: https://www.lowellmfg.com/wp-content/uploads/2127-ESP82TW.pdf; Product Page URL: https://www.lowellmfg.com/product/pendant-speaker-esp-82tw-8-coaxial/; Produttore: Lowell Manufacturing; Titolo OmniClass: Speakers; URL: https://www.lowellmfg.com/
Type - Dimensioni - Diameter: 0.339725 m; Height: 0.350838 m
Type - Elettrico - Power Factor: 1; Connector Type: Removable (4 pin) Phoenix-style; Driver Type: 8 in. 120W coaxial; Frequency response: 64Hz – 20kHZ ± 6dB; Impedance: 4; Load Classification: Other; Power handling: 120W RMS; Transformer Power: 120 W; Voltage: 100 V
Type - Materiali e finiture - Material Enclosure: Plastic - Lowell - White; Material Grille: Steel - Lowell - White
Type - Meccanica - SPL Max: 110.8
Type - Proprietà modello - Sensitivity: 90.0 dB
Type - Strutturale - Weight: 0.0693923 kN
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Visibilità - Bracket Visibility: yes; Cable Visibility: no; Pipe Visibility: no
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DCA_I_DiffusoriAPlafone(Scale)
Type - Pset_EnvironmentalImpactIndicators - Reference: DCA_I_DiffusoriAPlafone(Scale)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lowell Manufacturing
Material: Steel - Lowell - White, Plastic - Lowell - White
Altro - Famiglia: Electronics _Audio_Speakers_Lowell_ESP-82TW: DCA_I_DiffusoriAPlafone(Scale); Famiglia e tipo: Electronics _Audio_Speakers_Lowell_ESP-82TW: DCA_I_DiffusoriAPlafone(Scale); ID tipo: Electronics _Audio_Speakers_Lowell_ESP-82TW: DCA_I_DiffusoriAPlafone(Scale); Tipo: Electronics _Audio_Speakers_Lowell_ESP-82TW: DCA_I_DiffusoriAPlafone(Scale); z Cord length: 0.248444 m; z Cord length MAX: 3.048 m; z Cord length MIN: 0.0508 m; z Speaker offset: 0.197644 m; z Tilt Angle: 0 deg; z Tilt Angle MAX: 90 deg; z Tilt Angle MIN: -90 deg
Dimensioni - Area: 0.00104508 m2; Cord length: 0.1016 m; Tilt Angle: 0 deg; Volume: 0.0218852 m3
Elettrico - Input Voltage: Tap selections for 25V, 70V or 100V speaker systems
Elettrico - Circuiti - Dati elettrici: Power Connector 100 V/1-120 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Quota altimetrica da livello: 3 m
Name (Electronics _Audio_Speakers_Lowell_ESP-82TW:DCA_I_DiffusoriAPlafone(Scale):...) | In | Contrassegno | Livello = Livello abaco | Host
9594075 | L00 - Piano Terra Piazza ELETTRICO | 604 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602180 | L00 - Piano Terra Piazza ELETTRICO | 605 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9602249 | L00 - Piano Terra Piazza ELETTRICO | 606 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602328 | L00 - Piano Terra Piazza ELETTRICO | 607 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602356 | B01 - Piano Interrato ELETTRICO | 608 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602404 | B01 - Piano Interrato ELETTRICO | 609 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602455 | B01 - Piano Interrato ELETTRICO | 610 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9602527 | L00 - Piano Terra Piazza ELETTRICO | 611 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602593 | L00 - Piano Terra Piazza ELETTRICO | 612 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602660 | L00 - Piano Terra Piazza ELETTRICO | 613 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9602852 | L02 - Piano Secondo ELETTRICO | 614 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9602906 | L02 - Piano Secondo ELETTRICO | 615 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Electronics_Audio_JBL_Control-14-C-VA_Speaker:DCA_I_DiffusoriAControsoffitto (132)
Type - Material: JBL - Grid - White, JBL - Steel - White
Type - Altro - Categoria: Dispositivi di comunicazione; Nome famiglia: Electronics_Audio_JBL_Control-14-C-VA_Speaker
Type - Dati - HF Driver: 19 mm (3/4 in), highly-damped treated-silk dome, Kapton™ voice coil, liquid cooling, wide dispersion waveguide; LF Driver: 100 mm (4.0 inch) with polypropylene cone, butyl rubber surround, anodized aluminum voice coil former, high temperature voice coil
Type - Dati identità - Commenti sul tipo: Audio Evac; Descrizione: Two-Way 4in Co-axial CeilingLoudspeaker for EN54-24 Applications; Modello: Control 14C-VA; Nome del tipo: DCA_I_DiffusoriAControsoffitto; Numero OmniClass: 23.85.10.11.14.14.14; Product data url: https://www.bimobject.com/jbl-professional/product/control-14c-va-two-way-4-co-axial-ceiling-loudspeaker-en54-24; Produttore: JBL Professional; Titolo OmniClass: Loudspeakers; URL: http://www.jblpro.com/
Type - Dimensioni - Diameter: 0.19556 m; Height: 0.21844 m
Type - Elettrico - Input Connector: Input +, Input -, Earth (connected to backcan). Ceramic block with brass inserts (3.2 mm/0.126 in opening), accommodates 2.5 sq mm / 12 AWG wire; Power Capacity (Continuous Pink Noise): 30 W; Power Capacity (Continuous Program Power): 60 W; Transformer Taps: 3.2W
Type - Generale - Edition number: 1
Type - Materiali e finiture - Material Grill: JBL - Grid - White; Material Metal: JBL - Steel - White
Type - Proprietà modello - Directivity Factor: 7.6; Directivity Index: 8.1 dB; Frequency Range: 74 Hz – 20 kHz; Frequency Response: 100 Hz – 15 kHz; Mounting/Suspension: C-ring support backing plate,2 tile support rails (for 2 ft or 600 mm tile spans); Nominal Coverage Angle: 120° conical coverage; Nominal Impedance: 8Ω; Nominal Sensitivity: 87 dB; Rated Maximum SPL: 102 dB @ 1 m (3.3 ft) average, 108 dB peak; Weight: 2.17724 kg
Type - Vincoli - Prospetto di default: 2.4384 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DCA_I_DiffusoriAControsoffitto
Type - Pset_EnvironmentalImpactIndicators - Reference: DCA_I_DiffusoriAControsoffitto
Type - Pset_ManufacturerTypeInformation - Manufacturer: JBL Professional
Material: JBL - Steel - White, JBL - Steel - Black Mat, JBL - Grid - White
Altro - Famiglia: Electronics_Audio_JBL_Control-14-C-VA_Speaker: DCA_I_DiffusoriAControsoffitto; Famiglia e tipo: Electronics_Audio_JBL_Control-14-C-VA_Speaker: DCA_I_DiffusoriAControsoffitto; ID tipo: Electronics_Audio_JBL_Control-14-C-VA_Speaker: DCA_I_DiffusoriAControsoffitto; Tipo: Electronics_Audio_JBL_Control-14-C-VA_Speaker: DCA_I_DiffusoriAControsoffitto
Dimensioni - Area: 0.127972 m2; Volume: 0.00292778 m3
Elettrico - Circuiti - Dati elettrici: Input +, Input -, Earth (connected to backcan). Ceramic block with brass inserts (3.2 mm/0.126 in opening), accommodates 2.5 sq mm / 12 AWG wire 0 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Name (Electronics_Audio_JBL_Control-14-C-VA_Speaker:DCA_I_DiffusoriAControsoffitto:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9119197 | L00 - Piano Terra Piazza ELETTRICO | 450 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9134757 | L00 - Piano Terra Piazza ELETTRICO | 451 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9134773 | L00 - Piano Terra Piazza ELETTRICO | 452 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9134781 | L00 - Piano Terra Piazza ELETTRICO | 453 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9134789 | L00 - Piano Terra Piazza ELETTRICO | 454 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9134797 | L00 - Piano Terra Piazza ELETTRICO | 455 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9135055 | L00 - Piano Terra Piazza ELETTRICO | 456 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9135083 | L00 - Piano Terra Piazza ELETTRICO | 457 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9135106 | L00 - Piano Terra Piazza ELETTRICO | 458 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9135119 | L00 - Piano Terra Piazza ELETTRICO | 459 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9135141 | L00 - Piano Terra Piazza ELETTRICO | 460 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9135170 | L00 - Piano Terra Piazza ELETTRICO | 461 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9135240 | L00 - Piano Terra Piazza ELETTRICO | 462 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9135309 | L00 - Piano Terra Piazza ELETTRICO | 463 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9135479 | L00 - Piano Terra Piazza ELETTRICO | 464 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9135499 | L00 - Piano Terra Piazza ELETTRICO | 465 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9135515 | L00 - Piano Terra Piazza ELETTRICO | 466 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9136235 | L00 - Piano Terra Piazza ELETTRICO | 470 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136243 | L00 - Piano Terra Piazza ELETTRICO | 471 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136251 | L00 - Piano Terra Piazza ELETTRICO | 472 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136301 | L00 - Piano Terra Piazza ELETTRICO | 473 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136311 | L00 - Piano Terra Piazza ELETTRICO | 474 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136319 | L00 - Piano Terra Piazza ELETTRICO | 475 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136330 | L00 - Piano Terra Piazza ELETTRICO | 476 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136338 | L00 - Piano Terra Piazza ELETTRICO | 477 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136348 | L00 - Piano Terra Piazza ELETTRICO | 478 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9136360 | L00 - Piano Terra Piazza ELETTRICO | 479 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139505 | L00 - Piano Terra Piazza ELETTRICO | 480 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139561 | L00 - Piano Terra Piazza ELETTRICO | 481 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139571 | L00 - Piano Terra Piazza ELETTRICO | 482 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139598 | L00 - Piano Terra Piazza ELETTRICO | 483 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139636 | L00 - Piano Terra Piazza ELETTRICO | 484 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9139717 | L00 - Piano Terra Piazza ELETTRICO | 485 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139725 | L00 - Piano Terra Piazza ELETTRICO | 486 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139737 | L00 - Piano Terra Piazza ELETTRICO | 487 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139815 | L00 - Piano Terra Piazza ELETTRICO | 488 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139825 | L00 - Piano Terra Piazza ELETTRICO | 489 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139833 | L00 - Piano Terra Piazza ELETTRICO | 490 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9139918 | L00 - Piano Terra Piazza ELETTRICO | 491 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140414 | L00 - Piano Terra Piazza ELETTRICO | 492 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140429 | L00 - Piano Terra Piazza ELETTRICO | 493 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9140448 | L00 - Piano Terra Piazza ELETTRICO | 494 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9140501 | L00 - Piano Terra Piazza ELETTRICO | 495 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9140514 | L00 - Piano Terra Piazza ELETTRICO | 496 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140524 | L00 - Piano Terra Piazza ELETTRICO | 497 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140552 | L00 - Piano Terra Piazza ELETTRICO | 498 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140562 | L00 - Piano Terra Piazza ELETTRICO | 499 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140584 | L00 - Piano Terra Piazza ELETTRICO | 500 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140612 | L00 - Piano Terra Piazza ELETTRICO | 501 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140634 | L00 - Piano Terra Piazza ELETTRICO | 502 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140645 | L00 - Piano Terra Piazza ELETTRICO | 503 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140655 | L00 - Piano Terra Piazza ELETTRICO | 504 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140676 | L00 - Piano Terra Piazza ELETTRICO | 505 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140690 | L00 - Piano Terra Piazza ELETTRICO | 506 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140709 | L00 - Piano Terra Piazza ELETTRICO | 507 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140725 | L00 - Piano Terra Piazza ELETTRICO | 508 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140749 | L00 - Piano Terra Piazza ELETTRICO | 509 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140762 | L00 - Piano Terra Piazza ELETTRICO | 510 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140799 | L00 - Piano Terra Piazza ELETTRICO | 511 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140850 | L00 - Piano Terra Piazza ELETTRICO | 512 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9140875 | L00 - Piano Terra Piazza ELETTRICO | 513 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9140921 | L00 - Piano Terra Piazza ELETTRICO | 514 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9140937 | L00 - Piano Terra Piazza ELETTRICO | 515 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9140976 | L00 - Piano Terra Piazza ELETTRICO | 517 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141008 | L00 - Piano Terra Piazza ELETTRICO | 519 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141051 | L00 - Piano Terra Piazza ELETTRICO | 520 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141194 | L00 - Piano Terra Piazza ELETTRICO | 522 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9141203 | L00 - Piano Terra Piazza ELETTRICO | 523 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9141213 | L00 - Piano Terra Piazza ELETTRICO | 524 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9141427 | L00 - Piano Terra Piazza ELETTRICO | 525 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141437 | L00 - Piano Terra Piazza ELETTRICO | 526 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141445 | L00 - Piano Terra Piazza ELETTRICO | 527 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141504 | L00 - Piano Terra Piazza ELETTRICO | 528 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9141512 | L00 - Piano Terra Piazza ELETTRICO | 529 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9141520 | L00 - Piano Terra Piazza ELETTRICO | 530 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9141582 | L00 - Piano Terra Piazza ELETTRICO | 531 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9141645 | L00 - Piano Terra Piazza ELETTRICO | 532 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9141699 | L00 - Piano Terra Piazza ELETTRICO | 533 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141765 | L00 - Piano Terra Piazza ELETTRICO | 534 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141777 | L00 - Piano Terra Piazza ELETTRICO | 535 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141785 | L00 - Piano Terra Piazza ELETTRICO | 536 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141797 | L00 - Piano Terra Piazza ELETTRICO | 537 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141809 | L00 - Piano Terra Piazza ELETTRICO | 538 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9141819 | L00 - Piano Terra Piazza ELETTRICO | 539 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9141831 | L00 - Piano Terra Piazza ELETTRICO | 540 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9141840 | L00 - Piano Terra Piazza ELETTRICO | 541 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9141867 | L00 - Piano Terra Piazza ELETTRICO | 542 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9141910 | L00 - Piano Terra Piazza ELETTRICO | 543 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9142006 | L00 - Piano Terra Piazza ELETTRICO | 544 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142598 | L02 - Piano Secondo ELETTRICO | 545 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9142620 | L02 - Piano Secondo ELETTRICO | 546 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142657 | L02 - Piano Secondo ELETTRICO | 547 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142670 | L02 - Piano Secondo ELETTRICO | 548 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142699 | L02 - Piano Secondo ELETTRICO | 549 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142732 | L02 - Piano Secondo ELETTRICO | 551 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142742 | L02 - Piano Secondo ELETTRICO | 552 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142769 | L02 - Piano Secondo ELETTRICO | 553 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142780 | L02 - Piano Secondo ELETTRICO | 554 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142793 | L02 - Piano Secondo ELETTRICO | 555 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142812 | L02 - Piano Secondo ELETTRICO | 556 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142837 | L02 - Piano Secondo ELETTRICO | 557 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142850 | L02 - Piano Secondo ELETTRICO | 558 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142869 | L02 - Piano Secondo ELETTRICO | 559 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142888 | L02 - Piano Secondo ELETTRICO | 560 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9142952 | L02 - Piano Secondo ELETTRICO | 561 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9142968 | L02 - Piano Secondo ELETTRICO | 562 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143008 | L02 - Piano Secondo ELETTRICO | 563 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143024 | L02 - Piano Secondo ELETTRICO | 564 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143034 | L02 - Piano Secondo ELETTRICO | 565 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143133 | L02 - Piano Secondo ELETTRICO | 568 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143152 | L02 - Piano Secondo ELETTRICO | 569 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143183 | L02 - Piano Secondo ELETTRICO | 570 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143228 | L02 - Piano Secondo ELETTRICO | 572 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143295 | L02 - Piano Secondo ELETTRICO | 573 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143305 | L02 - Piano Secondo ELETTRICO | 574 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143333 | L02 - Piano Secondo ELETTRICO | 575 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143344 | L02 - Piano Secondo ELETTRICO | 576 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143357 | L02 - Piano Secondo ELETTRICO | 577 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143374 | L02 - Piano Secondo ELETTRICO | 578 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143395 | L02 - Piano Secondo ELETTRICO | 579 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143485 | L02 - Piano Secondo ELETTRICO | 580 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143655 | L02 - Piano Secondo ELETTRICO | 581 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143667 | L02 - Piano Secondo ELETTRICO | 582 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143677 | L02 - Piano Secondo ELETTRICO | 583 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143685 | L02 - Piano Secondo ELETTRICO | 584 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143695 | L02 - Piano Secondo ELETTRICO | 585 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143703 | L02 - Piano Secondo ELETTRICO | 586 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143711 | L02 - Piano Secondo ELETTRICO | 587 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143719 | L02 - Piano Secondo ELETTRICO | 588 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143813 | L02 - Piano Secondo ELETTRICO | 589 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9143827 | L02 - Piano Secondo ELETTRICO | 590 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9144050 | L02 - Piano Secondo ELETTRICO | 591 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3

# IfcBuildingElementProxy: Microfono:DCA_I_Microfono (2)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Asta
Type - Altro - Categoria: Dispositivi di comunicazione; Nome famiglia: Microfono
Type - Dati identità - Commenti sul tipo: Audio Evac; Nome del tipo: DCA_I_Microfono
Type - Vincoli - Prospetto di default: 0.9 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DCA_I_Microfono
Type - Pset_EnvironmentalImpactIndicators - Reference: DCA_I_Microfono
Material: Asta, Asta base, Pulsante, Pulsante base, Base
Altro - Famiglia: Microfono: DCA_I_Microfono; Famiglia e tipo: Microfono: DCA_I_Microfono; ID tipo: Microfono: DCA_I_Microfono; Tipo: Microfono: DCA_I_Microfono
Dimensioni - Volume: 0.000797451 m3
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Quota altimetrica da livello: 0.75 m
Name (Microfono:DCA_I_Microfono:...) | Contrassegno | Host
10474347 | 617 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
10474440 | 618 | <non associato>

# IfcBuildingElementProxy: Pannello Fotovoltaico:EEQ_E_PannelloFotovoltaico (564)
In: L03 - Piano Terzo ELETTRICO
Type - Classification: D5090 Other Electrical Systems (Uniformat); Material: SolarPanel Blu
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Pannello Fotovoltaico
Type - Dati - Operating Temperature: -40°F up to +185°F; Weight: 0.197946
Type - Dati identità - Codice assieme: D5090; Commenti sul tipo: FVT; Descrizione assieme: Other Electrical Systems; Nome del tipo: EEQ_E_PannelloFotovoltaico; Numero OmniClass: 23.75.10.27; Product data url: https://bimobject.com/tesla/product/tesla-solar-panels; Product url: https://www.tesla.com/solarpanels; Produttore: Tesla; Titolo OmniClass: Solar Collectors; URL: https://www.tesla.com/solarpanels
Type - Dimensioni - Depth: 0.0398859 m; Height: 1.00072 m; Width: 1.68404 m
Type - Elettrico - Number of Poles: 1; Power Factor: 1; Apparent Load: 315 W; Load Classification: Other; Voltage: 0 V; Wattage: 315 W
Type - Generale - Edition number: 1; Brand url: https://www.tesla.com/; Date of publishing: 2/14/2019; Design country: United States; Manufacturer country: United States; Manufacturer name: Tesla; Nominal height: 1.68402 m; Nominal width: 1.00076 m; Product family: Energy; Product group: Solar Panels; Product SKU: tesla-solar-panels; QR code: http://bimobject.com/tesla/product/tesla-solar-panels; Region North America: US; Weight Net (Kg): 44.5
Type - Materiali e finiture - Material main: Other; Material secondary: Aluminium
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_E_PannelloFotovoltaico
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_E_PannelloFotovoltaico
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tesla
Material: SolarPanel Blu, Anodized Aluminium
Altro - Famiglia: Pannello Fotovoltaico: EEQ_E_PannelloFotovoltaico; Famiglia e tipo: Pannello Fotovoltaico: EEQ_E_PannelloFotovoltaico; ID tipo: Pannello Fotovoltaico: EEQ_E_PannelloFotovoltaico; Tipo: Pannello Fotovoltaico: EEQ_E_PannelloFotovoltaico
Dimensioni - Area: 2.06097 m2; Volume: 0.0693477 m3
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase A carico apparente capicorda passanti: 0 W; Fase A carico apparente circuito derivato: 0 W; Fase B carico apparente: 0 W; Fase B carico apparente capicorda passanti: 0 W; Fase B carico apparente circuito derivato: 0 W; Fase C carico apparente: 0 W; Fase C carico apparente capicorda passanti: 0 W; Fase C carico apparente circuito derivato: 0 W; Fattore di richiesta totale: 100; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Elettrico - Circuiti - Opzione numerazione circuiti: Default; Dati elettrici: 0 V/1-315 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L03 - Piano Terzo ELETTRICO; Livello abaco: Livello: L03 - Piano Terzo ELETTRICO
Name (Pannello Fotovoltaico:EEQ_E_PannelloFotovoltaico:...) | Host | Quota altimetrica da livello (m)
9313260 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9313274 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9313321 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321336 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321337 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321338 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321370 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321371 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321372 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321387 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321388 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321389 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321398 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321399 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321400 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321409 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321410 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321411 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321422 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321423 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321424 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321431 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321432 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321433 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321442 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321443 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321444 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321455 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321456 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321457 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321478 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321479 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321480 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321506 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321507 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321508 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321509 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321510 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321511 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321512 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321513 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321514 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321515 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321516 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321517 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321518 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321519 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321520 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321521 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321522 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321523 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321524 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321525 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321526 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321527 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321528 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321529 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321530 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321531 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321532 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321533 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321534 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321535 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321544 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321545 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321546 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
