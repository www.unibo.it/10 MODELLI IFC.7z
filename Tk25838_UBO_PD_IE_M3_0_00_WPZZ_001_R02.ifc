Properties of the parts of a building model (IFC4), part 22 of 23

# IfcLightFixture: OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46026 (103)
Name (OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46026:...) | In | Contrassegno | Livello = Livello abaco | Piano di lavoro | Quota altimetrica da livello (m)
9663053 | L02 - Piano Secondo ELETTRICO | 6164 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663083 | L02 - Piano Secondo ELETTRICO | 6166 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663098 | L02 - Piano Secondo ELETTRICO | 6167 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663140 | L02 - Piano Secondo ELETTRICO | 6169 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663158 | L02 - Piano Secondo ELETTRICO | 6170 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663182 | L02 - Piano Secondo ELETTRICO | 6171 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663200 | L02 - Piano Secondo ELETTRICO | 6172 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663221 | L02 - Piano Secondo ELETTRICO | 6173 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663284 | L02 - Piano Secondo ELETTRICO | 6176 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663302 | L02 - Piano Secondo ELETTRICO | 6177 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663332 | L02 - Piano Secondo ELETTRICO | 6178 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663359 | L02 - Piano Secondo ELETTRICO | 6179 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663431 | L02 - Piano Secondo ELETTRICO | 6184 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663443 | L02 - Piano Secondo ELETTRICO | 6185 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663461 | L02 - Piano Secondo ELETTRICO | 6186 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663518 | L02 - Piano Secondo ELETTRICO | 6189 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663536 | L02 - Piano Secondo ELETTRICO | 6190 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663554 | L02 - Piano Secondo ELETTRICO | 6191 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663572 | L02 - Piano Secondo ELETTRICO | 6192 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663602 | L02 - Piano Secondo ELETTRICO | 6193 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663877 | L02 - Piano Secondo ELETTRICO | 6194 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663892 | L02 - Piano Secondo ELETTRICO | 6195 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663913 | L02 - Piano Secondo ELETTRICO | 6196 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663934 | L02 - Piano Secondo ELETTRICO | 6197 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663961 | L02 - Piano Secondo ELETTRICO | 6198 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9664048 | L02 - Piano Secondo ELETTRICO | 6199 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9664136 | L02 - Piano Secondo ELETTRICO | 6200 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9664151 | L02 - Piano Secondo ELETTRICO | 6201 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9664172 | L02 - Piano Secondo ELETTRICO | 6202 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9719311 | L02 - Piano Secondo ELETTRICO | 6210 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720056 | L02 - Piano Secondo ELETTRICO | 6211 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720084 | L02 - Piano Secondo ELETTRICO | 6212 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720092 | L02 - Piano Secondo ELETTRICO | 6213 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720100 | L02 - Piano Secondo ELETTRICO | 6214 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720148 | L02 - Piano Secondo ELETTRICO | 6215 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3

# IfcLightFixture: OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46027 (91)
Type - Material: Verre, polycarbonate thermodurcissable blanc
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA (cerchio)
Type - Dati identità - Classe de Protection: IP65; Commenti sul tipo: 27; Descrizione: Spot muni de deux LED de grande puissance et de lentilles optiques créant un faisceau de lumière circulaire, idéal pour réaliser un éclairage dans des halles de grandes hauteurs. Spot apparent de faible hauteur, constitué d'un boîtier en polycarbonate étanche (IP65) permettant son installation dans des lieux humides ou poussiéreux, il est de plus pourvu d'une membrane de compensation de pression. Alimenté par une armoire d’énergie APG 230 VAC cet appareil est prévu pour être utilisé comme luminaire secours.; Indice de résist. aux chocs: IK04; Modello: SPP/230C; Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46027; Numero OmniClass: 23.80.70.00; Produttore: Aprotec; Titolo OmniClass: Lighting; URL: www.aprotec.ch
Type - Elettrico - Carichi - Alimentation: 230 V; Carico apparente: 10 W; Puissance LED: 3 W
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: 90 deg; Emetti da lunghezza linea: 0.6096 m; Definizione sorgente d'illuminazione (famiglia): Linea+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; File diagramma fotometrico: aprotec_spp_230c_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 480 lm; Illuminanza: 4.11151 lx; Intensità luminosa: 38.1972 cd; Temperatura colore iniziale: 4000 K; Watt: 3.23141 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46027
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46027
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aprotec
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46027; Famiglia e tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46027; ID tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46027; Tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46027
Dati identità - Déclaration de conformité: https://bim-mo.ch/wp-content/uploads/2019/03/SPP.pdf; Fiche technique: http://www.aprotec.ch/data/products/pdf/aprotec-spp-230c.pdf; Modélisation: www.bim-mo.ch; Notice de Montage: https://bim-mo.ch/wp-content/uploads/2019/03/SPP-1.pdf
Dimensioni - Volume: 0.00102695 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-10 W
Fasi - Fase di creazione: Nuova costruzione
Name (OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46027:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Piano di lavoro | Quota altimetrica da livello (m)
9501981 | L00 - Piano Terra Piazza ELETTRICO | 5624 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502039 | L00 - Piano Terra Piazza ELETTRICO | 5625 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502047 | L00 - Piano Terra Piazza ELETTRICO | 5626 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502059 | L00 - Piano Terra Piazza ELETTRICO | 5627 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505504 | L00 - Piano Terra Piazza ELETTRICO | 5779 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505548 | L00 - Piano Terra Piazza ELETTRICO | 5780 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505576 | L00 - Piano Terra Piazza ELETTRICO | 5781 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505577 | L00 - Piano Terra Piazza ELETTRICO | 5782 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505587 | L00 - Piano Terra Piazza ELETTRICO | 5783 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505588 | L00 - Piano Terra Piazza ELETTRICO | 5784 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505623 | L00 - Piano Terra Piazza ELETTRICO | 5785 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505624 | L00 - Piano Terra Piazza ELETTRICO | 5786 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505632 | L00 - Piano Terra Piazza ELETTRICO | 5787 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505633 | L00 - Piano Terra Piazza ELETTRICO | 5788 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505641 | L00 - Piano Terra Piazza ELETTRICO | 5789 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505642 | L00 - Piano Terra Piazza ELETTRICO | 5790 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505664 | L00 - Piano Terra Piazza ELETTRICO | 5791 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505674 | L00 - Piano Terra Piazza ELETTRICO | 5792 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505682 | L00 - Piano Terra Piazza ELETTRICO | 5793 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505692 | L00 - Piano Terra Piazza ELETTRICO | 5794 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9505774 | L00 - Piano Terra Piazza ELETTRICO | 5795 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9505850 | L00 - Piano Terra Piazza ELETTRICO | 5796 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9505877 | L00 - Piano Terra Piazza ELETTRICO | 5797 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9505954 | L00 - Piano Terra Piazza ELETTRICO | 5798 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9506080 | L00 - Piano Terra Piazza ELETTRICO | 5799 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506119 | L00 - Piano Terra Piazza ELETTRICO | 5800 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506127 | L00 - Piano Terra Piazza ELETTRICO | 5801 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506135 | L00 - Piano Terra Piazza ELETTRICO | 5802 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506145 | L00 - Piano Terra Piazza ELETTRICO | 5803 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506153 | L00 - Piano Terra Piazza ELETTRICO | 5804 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506161 | L00 - Piano Terra Piazza ELETTRICO | 5805 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506169 | L00 - Piano Terra Piazza ELETTRICO | 5806 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506180 | L00 - Piano Terra Piazza ELETTRICO | 5807 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506188 | L00 - Piano Terra Piazza ELETTRICO | 5808 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506202 | L00 - Piano Terra Piazza ELETTRICO | 5809 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506210 | L00 - Piano Terra Piazza ELETTRICO | 5810 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506222 | L00 - Piano Terra Piazza ELETTRICO | 5811 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506260 | L00 - Piano Terra Piazza ELETTRICO | 5812 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506273 | L00 - Piano Terra Piazza ELETTRICO | 5813 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506283 | L00 - Piano Terra Piazza ELETTRICO | 5814 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506291 | L00 - Piano Terra Piazza ELETTRICO | 5815 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506301 | L00 - Piano Terra Piazza ELETTRICO | 5816 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506315 | L00 - Piano Terra Piazza ELETTRICO | 5817 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506321 | L00 - Piano Terra Piazza ELETTRICO | 5818 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506329 | L00 - Piano Terra Piazza ELETTRICO | 5819 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506337 | L00 - Piano Terra Piazza ELETTRICO | 5820 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506345 | L00 - Piano Terra Piazza ELETTRICO | 5821 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506355 | L00 - Piano Terra Piazza ELETTRICO | 5822 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506367 | L00 - Piano Terra Piazza ELETTRICO | 5823 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506377 | L00 - Piano Terra Piazza ELETTRICO | 5824 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506385 | L00 - Piano Terra Piazza ELETTRICO | 5825 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506395 | L00 - Piano Terra Piazza ELETTRICO | 5826 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506405 | L00 - Piano Terra Piazza ELETTRICO | 5827 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506415 | L00 - Piano Terra Piazza ELETTRICO | 5828 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506423 | L00 - Piano Terra Piazza ELETTRICO | 5829 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506433 | L00 - Piano Terra Piazza ELETTRICO | 5830 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506441 | L00 - Piano Terra Piazza ELETTRICO | 5831 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506449 | L00 - Piano Terra Piazza ELETTRICO | 5832 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506457 | L00 - Piano Terra Piazza ELETTRICO | 5833 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506465 | L00 - Piano Terra Piazza ELETTRICO | 5834 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506473 | L00 - Piano Terra Piazza ELETTRICO | 5835 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9506774 | L00 - Piano Terra Piazza ELETTRICO | 5850 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506808 | L00 - Piano Terra Piazza ELETTRICO | 5851 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506816 | L00 - Piano Terra Piazza ELETTRICO | 5852 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506824 | L00 - Piano Terra Piazza ELETTRICO | 5853 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506832 | L00 - Piano Terra Piazza ELETTRICO | 5854 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506840 | L00 - Piano Terra Piazza ELETTRICO | 5855 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507122 | L00 - Piano Terra Piazza ELETTRICO | 5862 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 4
9507163 | L00 - Piano Terra Piazza ELETTRICO | 5863 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 4
9507173 | L00 - Piano Terra Piazza ELETTRICO | 5864 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 4
9507183 | L00 - Piano Terra Piazza ELETTRICO | 5865 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 4
9507652 | L02 - Piano Secondo ELETTRICO | 5875 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507691 | L02 - Piano Secondo ELETTRICO | 5876 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507721 | L02 - Piano Secondo ELETTRICO | 5877 | Livello: L02 - Piano Secondo ELETTRICO | -0.00927299 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.99073
9507729 | L02 - Piano Secondo ELETTRICO | 5878 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507741 | L02 - Piano Secondo ELETTRICO | 5879 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507749 | L02 - Piano Secondo ELETTRICO | 5880 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507759 | L02 - Piano Secondo ELETTRICO | 5881 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507769 | L02 - Piano Secondo ELETTRICO | 5882 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507781 | L02 - Piano Secondo ELETTRICO | 5883 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507799 | L02 - Piano Secondo ELETTRICO | 5885 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663071 | L02 - Piano Secondo ELETTRICO | 6165 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663110 | L02 - Piano Secondo ELETTRICO | 6168 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663248 | L02 - Piano Secondo ELETTRICO | 6174 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663260 | L02 - Piano Secondo ELETTRICO | 6175 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663383 | L02 - Piano Secondo ELETTRICO | 6180 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663395 | L02 - Piano Secondo ELETTRICO | 6181 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663407 | L02 - Piano Secondo ELETTRICO | 6182 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663419 | L02 - Piano Secondo ELETTRICO | 6183 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663473 | L02 - Piano Secondo ELETTRICO | 6187 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9663488 | L02 - Piano Secondo ELETTRICO | 6188 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3

# IfcLightFixture: OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46029 (10)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Verre, polycarbonate thermodurcissable blanc
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA (quadrate)
Type - Dati identità - Classe de Protection: IP65; Commenti sul tipo: 29; Descrizione: Spot muni de deux LED de grande puissance et de lentilles optiques créant un faisceau de lumière circulaire, idéal pour réaliser un éclairage dans des halles de grandes hauteurs. Spot apparent de faible hauteur, constitué d'un boîtier en polycarbonate étanche (IP65) permettant son installation dans des lieux humides ou poussiéreux, il est de plus pourvu d'une membrane de compensation de pression. Alimenté par une armoire d’énergie APG 230 VAC cet appareil est prévu pour être utilisé comme luminaire secours.; Indice de résist. aux chocs: IK04; Modello: SPP/230C; Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46029; Numero OmniClass: 23.80.70.00; Produttore: Aprotec; Titolo OmniClass: Lighting; URL: www.aprotec.ch
Type - Elettrico - Carichi - Alimentation: 230 V; Carico apparente: 10 W; Puissance LED: 3 W
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: 90 deg; Definizione sorgente d'illuminazione (famiglia): Linea+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; Emetti da lunghezza linea: 0.6096 m; File diagramma fotometrico: aprotec_spp_230c_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 480 lm; Illuminanza: 4.11151 lx; Intensità luminosa: 38.1972 cd; Temperatura colore iniziale: 4000 K; Watt: 3.23141 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46029
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46029
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aprotec
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46029; Famiglia e tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46029; ID tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46029; Tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46029
Dati identità - Déclaration de conformité: https://bim-mo.ch/wp-content/uploads/2019/03/SPP.pdf; Fiche technique: http://www.aprotec.ch/data/products/pdf/aprotec-spp-230c.pdf; Modélisation: www.bim-mo.ch; Notice de Montage: https://bim-mo.ch/wp-content/uploads/2019/03/SPP-1.pdf
Dimensioni - Volume: 0.00102695 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-10 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO
Name (OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46029:...) | Contrassegno | Offset da host (m) | Piano di lavoro | Quota altimetrica da livello (m)
9486682 | 5422 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493637 | 5485 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493649 | 5486 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493659 | 5487 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493667 | 5488 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493767 | 5489 | -0.0350563 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.26494
9493874 | 5491 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493892 | 5492 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493910 | 5493 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9493948 | 5494 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6

# IfcLightFixture: OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46030 (13)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Verre, polycarbonate thermodurcissable blanc
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA (quadrate)
Type - Dati identità - Classe de Protection: IP65; Commenti sul tipo: 30; Descrizione: Spot muni de deux LED de grande puissance et de lentilles optiques créant un faisceau de lumière circulaire, idéal pour réaliser un éclairage dans des halles de grandes hauteurs. Spot apparent de faible hauteur, constitué d'un boîtier en polycarbonate étanche (IP65) permettant son installation dans des lieux humides ou poussiéreux, il est de plus pourvu d'une membrane de compensation de pression. Alimenté par une armoire d’énergie APG 230 VAC cet appareil est prévu pour être utilisé comme luminaire secours.; Indice de résist. aux chocs: IK04; Modello: SPP/230C; Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46030; Numero OmniClass: 23.80.70.00; Produttore: Aprotec; Titolo OmniClass: Lighting; URL: www.aprotec.ch
Type - Elettrico - Carichi - Alimentation: 230 V; Carico apparente: 10 W; Puissance LED: 3 W
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: 90 deg; Emetti da lunghezza linea: 0.6096 m; Definizione sorgente d'illuminazione (famiglia): Linea+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; File diagramma fotometrico: aprotec_spp_230c_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 480 lm; Illuminanza: 4.11151 lx; Intensità luminosa: 38.1972 cd; Temperatura colore iniziale: 4000 K; Watt: 3.23141 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46030
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46030
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aprotec
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46030; Famiglia e tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46030; ID tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46030; Tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46030
Dati identità - Déclaration de conformité: https://bim-mo.ch/wp-content/uploads/2019/03/SPP.pdf; Fiche technique: http://www.aprotec.ch/data/products/pdf/aprotec-spp-230c.pdf; Modélisation: www.bim-mo.ch; Notice de Montage: https://bim-mo.ch/wp-content/uploads/2019/03/SPP-1.pdf
Dimensioni - Volume: 0.00102695 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-10 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO
Name (OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46030:...) | Contrassegno | Offset da host (m) | Piano di lavoro | Quota altimetrica da livello (m)
9493005 | 5470 | 0.002 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.301
9493134 | 5471 | 0.002 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.301
9493144 | 5472 | 0.002 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.301
9493152 | 5473 | 0.002 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.301
9493285 | 5478 | 0.261 | <non associato> | 3.301
9493329 | 5479 | -0.106677 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.93332
9493426 | 5480 | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9493434 | 5481 | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9493452 | 5482 | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9493522 | 5484 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
9698838 | 6080 | 0 | <non associato> | 2.5
9698839 | 6081 | 0 | <non associato> | 2.5
9698840 | 6082 | 0 | <non associato> | 2.5

# IfcLightFixture: OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46031 (39)
Type - Material: Verre, polycarbonate thermodurcissable blanc
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA (quadrate)
Type - Dati identità - Classe de Protection: IP65; Commenti sul tipo: 31; Descrizione: Spot muni de deux LED de grande puissance et de lentilles optiques créant un faisceau de lumière circulaire, idéal pour réaliser un éclairage dans des halles de grandes hauteurs. Spot apparent de faible hauteur, constitué d'un boîtier en polycarbonate étanche (IP65) permettant son installation dans des lieux humides ou poussiéreux, il est de plus pourvu d'une membrane de compensation de pression. Alimenté par une armoire d’énergie APG 230 VAC cet appareil est prévu pour être utilisé comme luminaire secours.; Indice de résist. aux chocs: IK04; Modello: SPP/230C; Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46031; Numero OmniClass: 23.80.70.00; Produttore: Aprotec; Titolo OmniClass: Lighting; URL: www.aprotec.ch
Type - Elettrico - Carichi - Alimentation: 230 V; Carico apparente: 10 W; Puissance LED: 3 W
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: 90 deg; Emetti da lunghezza linea: 0.6096 m; Definizione sorgente d'illuminazione (famiglia): Linea+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; File diagramma fotometrico: aprotec_spp_230c_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 480 lm; Illuminanza: 4.11151 lx; Intensità luminosa: 38.1972 cd; Temperatura colore iniziale: 4000 K; Watt: 3.23141 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46031
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46031
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aprotec
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46031; Famiglia e tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46031; ID tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46031; Tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46031
Dati identità - Déclaration de conformité: https://bim-mo.ch/wp-content/uploads/2019/03/SPP.pdf; Fiche technique: http://www.aprotec.ch/data/products/pdf/aprotec-spp-230c.pdf; Modélisation: www.bim-mo.ch; Notice de Montage: https://bim-mo.ch/wp-content/uploads/2019/03/SPP-1.pdf
Dimensioni - Volume: 0.00102695 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-10 W
Fasi - Fase di creazione: Nuova costruzione
Name (OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46031:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Piano di lavoro | Quota altimetrica da livello (m)
9492533 | B01 - Piano Interrato ELETTRICO | 5433 | Livello: B01 - Piano Interrato ELETTRICO | -0.315507 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.28449
9492632 | B01 - Piano Interrato ELETTRICO | 5434 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492649 | B01 - Piano Interrato ELETTRICO | 5435 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492662 | B01 - Piano Interrato ELETTRICO | 5436 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492670 | B01 - Piano Interrato ELETTRICO | 5437 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492682 | B01 - Piano Interrato ELETTRICO | 5438 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492690 | B01 - Piano Interrato ELETTRICO | 5439 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492700 | B01 - Piano Interrato ELETTRICO | 5440 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.17989
9492708 | B01 - Piano Interrato ELETTRICO | 5441 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492720 | B01 - Piano Interrato ELETTRICO | 5442 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492728 | B01 - Piano Interrato ELETTRICO | 5443 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492736 | B01 - Piano Interrato ELETTRICO | 5444 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492744 | B01 - Piano Interrato ELETTRICO | 5445 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492752 | B01 - Piano Interrato ELETTRICO | 5446 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492762 | B01 - Piano Interrato ELETTRICO | 5447 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492770 | B01 - Piano Interrato ELETTRICO | 5448 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492778 | B01 - Piano Interrato ELETTRICO | 5449 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492790 | B01 - Piano Interrato ELETTRICO | 5450 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492800 | B01 - Piano Interrato ELETTRICO | 5451 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492810 | B01 - Piano Interrato ELETTRICO | 5452 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492818 | B01 - Piano Interrato ELETTRICO | 5453 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492830 | B01 - Piano Interrato ELETTRICO | 5454 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492840 | B01 - Piano Interrato ELETTRICO | 5455 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492852 | B01 - Piano Interrato ELETTRICO | 5456 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492862 | B01 - Piano Interrato ELETTRICO | 5457 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492870 | B01 - Piano Interrato ELETTRICO | 5458 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492878 | B01 - Piano Interrato ELETTRICO | 5459 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492888 | B01 - Piano Interrato ELETTRICO | 5460 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9492898 | B01 - Piano Interrato ELETTRICO | 5461 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9492908 | B01 - Piano Interrato ELETTRICO | 5462 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9492918 | B01 - Piano Interrato ELETTRICO | 5463 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9492926 | B01 - Piano Interrato ELETTRICO | 5464 | Livello: B01 - Piano Interrato ELETTRICO | -0.140225 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.35977
9492936 | B01 - Piano Interrato ELETTRICO | 5465 | Livello: B01 - Piano Interrato ELETTRICO | -0.175281 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.32472
9492944 | B01 - Piano Interrato ELETTRICO | 5466 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9492952 | B01 - Piano Interrato ELETTRICO | 5467 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492960 | B01 - Piano Interrato ELETTRICO | 5468 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | <non associato> | 2.56494
9492972 | B01 - Piano Interrato ELETTRICO | 5469 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.91989
9493824 | B01 - Piano Interrato ELETTRICO | 5490 | Livello: B01 - Piano Interrato ELETTRICO | -0.0701126 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.42989
9499940 | L00 - Piano Terra Piazza ELETTRICO | 5523 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4

# IfcLightFixture: OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46032 (38)
Type - Material: Verre, polycarbonate thermodurcissable blanc
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA (quadrate)
Type - Dati identità - Classe de Protection: IP65; Commenti sul tipo: 32; Descrizione: Spot muni de deux LED de grande puissance et de lentilles optiques créant un faisceau de lumière circulaire, idéal pour réaliser un éclairage dans des halles de grandes hauteurs. Spot apparent de faible hauteur, constitué d'un boîtier en polycarbonate étanche (IP65) permettant son installation dans des lieux humides ou poussiéreux, il est de plus pourvu d'une membrane de compensation de pression. Alimenté par une armoire d’énergie APG 230 VAC cet appareil est prévu pour être utilisé comme luminaire secours.; Indice de résist. aux chocs: IK04; Modello: SPP/230C; Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46032; Numero OmniClass: 23.80.70.00; Produttore: Aprotec; Titolo OmniClass: Lighting; URL: www.aprotec.ch
Type - Elettrico - Carichi - Alimentation: 230 V; Carico apparente: 10 W; Puissance LED: 3 W
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: 90 deg; Emetti da lunghezza linea: 0.6096 m; Definizione sorgente d'illuminazione (famiglia): Linea+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; File diagramma fotometrico: aprotec_spp_230c_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 480 lm; Illuminanza: 4.11151 lx; Intensità luminosa: 38.1972 cd; Temperatura colore iniziale: 4000 K; Watt: 3.23141 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46032
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46032
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aprotec
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46032; Famiglia e tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46032; ID tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46032; Tipo: OVA (quadrate): LFX_I_IguzziniMod._TipoOvaMod.46032
Dati identità - Déclaration de conformité: https://bim-mo.ch/wp-content/uploads/2019/03/SPP.pdf; Fiche technique: http://www.aprotec.ch/data/products/pdf/aprotec-spp-230c.pdf; Modélisation: www.bim-mo.ch; Notice de Montage: https://bim-mo.ch/wp-content/uploads/2019/03/SPP-1.pdf
Dimensioni - Volume: 0.00102695 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-10 W
Fasi - Fase di creazione: Nuova costruzione
Name (OVA (quadrate):LFX_I_IguzziniMod._TipoOvaMod.46032:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Piano di lavoro | Quota altimetrica da livello (m)
9491932 | B01 - Piano Interrato ELETTRICO | 5423 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.46494
9491963 | L00 - Piano Terra Piazza ELETTRICO | 5424 | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.0350563 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.96494
9492001 | B01 - Piano Interrato ELETTRICO | 5425 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.00494
9492197 | B01 - Piano Interrato ELETTRICO | 5428 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.26494
9492417 | B01 - Piano Interrato ELETTRICO | 5430 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
9492470 | B01 - Piano Interrato ELETTRICO | 5431 | Livello: B01 - Piano Interrato ELETTRICO | 0 | <non associato> | 3.3
9492485 | B01 - Piano Interrato ELETTRICO | 5432 | Livello: B01 - Piano Interrato ELETTRICO | 0.122 | <non associato> | 3.422
9493241 | B01 - Piano Interrato ELETTRICO | 5477 | Livello: B01 - Piano Interrato ELETTRICO | -0.0350563 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.00494
9499911 | L00 - Piano Terra Piazza ELETTRICO | 5522 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502604 | L00 - Piano Terra Piazza ELETTRICO | 5653 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | <non associato> | 5.395
9502759 | L00 - Piano Terra Piazza ELETTRICO | 5656 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.36364
9502783 | L00 - Piano Terra Piazza ELETTRICO | 5657 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.00606
9502838 | L00 - Piano Terra Piazza ELETTRICO | 5658 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 5.28
9502873 | L00 - Piano Terra Piazza ELETTRICO | 5659 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.68485
9502908 | L00 - Piano Terra Piazza ELETTRICO | 5660 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.17576
9503008 | L00 - Piano Terra Piazza ELETTRICO | 5661 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 5.4
9503049 | L00 - Piano Terra Piazza ELETTRICO | 5662 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.34545
9503075 | L00 - Piano Terra Piazza ELETTRICO | 5663 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.85455
9503147 | L00 - Piano Terra Piazza ELETTRICO | 5665 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | <non associato> | 5.395
9507000 | L00 - Piano Terra Piazza ELETTRICO | 5859 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
9507034 | L00 - Piano Terra Piazza ELETTRICO | 5860 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
9507071 | L00 - Piano Terra Piazza ELETTRICO | 5861 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
9507225 | L00 - Piano Terra Piazza ELETTRICO | 5866 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.9
9507259 | L00 - Piano Terra Piazza ELETTRICO | 5867 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.86
9507270 | L00 - Piano Terra Piazza ELETTRICO | 5868 | Livello: L01 - Piano Primo ELETTRICO | -1.358 | <non associato> | 1.502
9507380 | L00 - Piano Terra Piazza ELETTRICO | 5871 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.78
9507419 | L00 - Piano Terra Piazza ELETTRICO | 5872 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.23
9507421 | L00 - Piano Terra Piazza ELETTRICO | 5873 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.01
9507496 | L00 - Piano Terra Piazza ELETTRICO | 5874 | Livello: L01 - Piano Primo ELETTRICO | -0.0762679 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.17373
9509158 | L02 - Piano Secondo ELETTRICO | 5958 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.855
9509160 | L02 - Piano Secondo ELETTRICO | 5959 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.855
9509292 | L03 - Piano Terzo ELETTRICO | 5963 | Livello: L03 - Piano Terzo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.324
9509333 | L03 - Piano Terzo ELETTRICO | 5964 | Livello: L03 - Piano Terzo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.324
9518293 | B01 - Piano Interrato ELETTRICO | 6001 | Livello: B01 - Piano Interrato ELETTRICO | 0 | <non associato> | 2.6
9698858 | L02 - Piano Secondo ELETTRICO | 6206 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9698860 | L02 - Piano Secondo ELETTRICO | 6207 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9698861 | L02 - Piano Secondo ELETTRICO | 6208 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9698864 | L02 - Piano Secondo ELETTRICO | 6209 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.784

# IfcLightFixture: OVA IP65:LFX_I_IguzziniMod._TipoOvaMod.46020 (38)
Type - Material: Vetro
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA IP65
Type - Dati identità - Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46020
Type - Elettrico - Commenti sul wattaggio: ILL SIC
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46020
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46020
Material: Vetro, Light, Body
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA IP65: LFX_I_IguzziniMod._TipoOvaMod.46020; Famiglia e tipo: OVA IP65: LFX_I_IguzziniMod._TipoOvaMod.46020; ID tipo: OVA IP65: LFX_I_IguzziniMod._TipoOvaMod.46020; Tipo: OVA IP65: LFX_I_IguzziniMod._TipoOvaMod.46020
Dimensioni - Volume: 0.00369557 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - Distanza simbolo: 0.5 m
Name (OVA IP65:LFX_I_IguzziniMod._TipoOvaMod.46020:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9493994 | B01 - Piano Interrato ELETTRICO | 5495 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.5
9503187 | L00 - Piano Terra Piazza ELETTRICO | 5666 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.4
9503316 | L00 - Piano Terra Piazza ELETTRICO | 5669 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3
9503383 | L00 - Piano Terra Piazza ELETTRICO | 5670 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3
9506864 | L00 - Piano Terra Piazza ELETTRICO | 5856 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506941 | L00 - Piano Terra Piazza ELETTRICO | 5858 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507304 | L00 - Piano Terra Piazza ELETTRICO | 5869 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9507323 | L00 - Piano Terra Piazza ELETTRICO | 5870 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9509231 | L02 - Piano Secondo ELETTRICO | 5961 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.8
9509249 | L02 - Piano Secondo ELETTRICO | 5962 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.8
9509357 | L03 - Piano Terzo ELETTRICO | 5965 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.126
9509379 | L03 - Piano Terzo ELETTRICO | 5966 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.126
9509399 | L03 - Piano Terzo ELETTRICO | 5967 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.126
9510544 | L02 - Piano Secondo ELETTRICO | 5968 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.82473
9510546 | L02 - Piano Secondo ELETTRICO | 5969 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.82473
9510640 | L02 - Piano Secondo ELETTRICO | 5970 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.82473
9518546 | L00 - Piano Terra Piazza ELETTRICO | 6002 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.35
9518587 | L00 - Piano Terra Piazza ELETTRICO | 6003 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.35
9518612 | L00 - Piano Terra Piazza ELETTRICO | 6004 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.35
9518640 | L00 - Piano Terra Piazza ELETTRICO | 6005 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.35
9523354 | L02 - Piano Secondo ELETTRICO | 6051 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.34774
9523356 | L00 - Piano Terra Piazza ELETTRICO | 6052 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.07909
9523358 | L00 - Piano Terra Piazza ELETTRICO | 6053 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.2
9523359 | L00 - Piano Terra Piazza ELETTRICO | 6054 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4.9032
9523361 | L00 - Piano Terra Piazza ELETTRICO | 6055 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.5
9523562 | L00 - Piano Terra Piazza ELETTRICO | 6056 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.5697
9523633 | L00 - Piano Terra Piazza ELETTRICO | 6057 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.57089
9523680 | L00 - Piano Terra Piazza ELETTRICO | 6058 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.56609
9523760 | L00 - Piano Terra Piazza ELETTRICO | 6059 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.5894
9523807 | L00 - Piano Terra Piazza ELETTRICO | 6060 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.56457
9523881 | L00 - Piano Terra Piazza ELETTRICO | 6061 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.53433
9523925 | L00 - Piano Terra Piazza ELETTRICO | 6062 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.54135
9524030 | L00 - Piano Terra Piazza ELETTRICO | 6063 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.44703
9524053 | L00 - Piano Terra Piazza ELETTRICO | 6064 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.46424
9524079 | L00 - Piano Terra Piazza ELETTRICO | 6065 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.46424
9524196 | L00 - Piano Terra Piazza ELETTRICO | 6066 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.57909
9524222 | L00 - Piano Terra Piazza ELETTRICO | 6067 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.53394
9524245 | L00 - Piano Terra Piazza ELETTRICO | 6068 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.60166

# IfcLightFixture: vie di esodo_incasso:Bottom (35)
Type - Material: Zumtobel_Metal_Aluminium
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: vie di esodo_incasso
Type - Dati identità - Nome del tipo: Bottom; Numero OmniClass: 23.80.70.11; Titolo OmniClass: Luminaries for Internal Lighting
Type - Dimensioni - Depth: 0.065 m; Height: 0.2214 m; Width: 0.3 m
Type - Elettrico - Commenti sul wattaggio: ILL SIC; Lampada: LED; Voltage: 24 V
Type - Elettrico - Carichi - Carico apparente: 4.5 W
Type - Grafica - Escape Bottom: yes; Escape Left & Right: no
Type - Materiali e finiture - Body: Zumtobel_Metal_Aluminium
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: Bottom
Type - Pset_LightFixtureTypeCommon - Reference: Bottom
Material: Zumtobel_Metal_Aluminium, Zumtobel_Escape_Sign_White_Self_Illumination, Zumtobel_Escape_Sign_Green_Self_Illumination, Zumtobel_PMMA_Semitransparent
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: vie di esodo_incasso: Bottom; Famiglia e tipo: vie di esodo_incasso: Bottom; ID tipo: vie di esodo_incasso: Bottom; Tipo: vie di esodo_incasso: Bottom
Dimensioni - Volume: 0.000516749 m3
Elettrico - Circuiti - Dati elettrici: 24 V/1-0 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Name (vie di esodo_incasso:Bottom:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9514381 | B01 - Piano Interrato ELETTRICO | 5974 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.95
9514455 | B01 - Piano Interrato ELETTRICO | 5975 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9514604 | B01 - Piano Interrato ELETTRICO | 5976 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.29
9516352 | B01 - Piano Interrato ELETTRICO | 5984 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9516404 | B01 - Piano Interrato ELETTRICO | 5985 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9516548 | B01 - Piano Interrato ELETTRICO | 5987 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9516613 | B01 - Piano Interrato ELETTRICO | 5988 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9516710 | B01 - Piano Interrato ELETTRICO | 5990 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
