Properties of the parts of a building model (IFC4), part 2 of 23

# IfcAlarm: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED:DFA_I_RivelatoreFumiASoffitto (190)
Name (Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED:DFA_I_RivelatoreFumiASoffitto:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9351327 | L00 - Piano Terra Piazza ELETTRICO | 2598 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351341 | L00 - Piano Terra Piazza ELETTRICO | 2599 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351348 | L00 - Piano Terra Piazza ELETTRICO | 2600 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351368 | L00 - Piano Terra Piazza ELETTRICO | 2601 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351400 | L00 - Piano Terra Piazza ELETTRICO | 2602 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351416 | L00 - Piano Terra Piazza ELETTRICO | 2603 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351450 | L00 - Piano Terra Piazza ELETTRICO | 2604 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351467 | L00 - Piano Terra Piazza ELETTRICO | 2605 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351555 | L00 - Piano Terra Piazza ELETTRICO | 2606 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351583 | L00 - Piano Terra Piazza ELETTRICO | 2607 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351596 | L00 - Piano Terra Piazza ELETTRICO | 2608 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351688 | L00 - Piano Terra Piazza ELETTRICO | 2609 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351748 | L00 - Piano Terra Piazza ELETTRICO | 2610 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351797 | L00 - Piano Terra Piazza ELETTRICO | 2611 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351829 | L00 - Piano Terra Piazza ELETTRICO | 2612 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351879 | L00 - Piano Terra Piazza ELETTRICO | 2613 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351896 | L00 - Piano Terra Piazza ELETTRICO | 2614 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351912 | L00 - Piano Terra Piazza ELETTRICO | 2615 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351929 | L00 - Piano Terra Piazza ELETTRICO | 2616 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9352079 | L00 - Piano Terra Piazza ELETTRICO | 2617 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9352131 | L00 - Piano Terra Piazza ELETTRICO | 2618 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9352138 | L00 - Piano Terra Piazza ELETTRICO | 2619 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9352151 | L00 - Piano Terra Piazza ELETTRICO | 2620 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9352182 | L00 - Piano Terra Piazza ELETTRICO | 2621 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9352295 | L00 - Piano Terra Piazza ELETTRICO | 2622 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9356556 | L02 - Piano Secondo ELETTRICO | 2623 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9356567 | L02 - Piano Secondo ELETTRICO | 2624 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9356574 | L02 - Piano Secondo ELETTRICO | 2625 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94

# IfcAlarm: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors:DFA_I_RivelatoreCo (14)
In: B01 - Piano Interrato ELETTRICO
Type - Classification: D5030700 Fire Alarm Systems (Uniformat); Material: High Impact Polymer - UTC - White
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors
Type - Dati - Agency Listings: CAN/ULC-S529, UL 268, UL 268A; Alarm Point: Analyzes data from the sensing chamber to determine whether to alarm; Environmental Compensation: Automatic; Mounting Information: Plug-in, Maximum 12 in (305mm) from ceiling; Spacing: N/A; Storage and Operating Environment: Air Velocity: 0 to 4000 ft/min (0 to 20 m/s); Operating Temperature: 32°F to 120°F (0°C to 49°C); Storage Temperature: -4°F to 140°F (-20°C to 60°C); Humidity: 0 to 93% RH, Non-Condensing
Type - Dati identità - Codice assieme: D5030700; Commenti sul tipo: CO; Copyright: Copyright © UTC Climate, Controls & Security; Date Last Modified: November 16, 2017; Descrizione: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Descrizione assieme: Fire Alarm Systems; Equipment Abbreviation: FS; Family Version: 1.0.0; Model Disclaimer: Contact UTC Climate, Controls & Security for more information.; Modello: SIGA-PD w/ SIGA-SB base; Nome del tipo: DFA_I_RivelatoreCo; Numero OmniClass: 23.85.30.21.11; Original Creation Date: November 16, 2017; Product data url: https://bimobject.com/edwardsutc/product/edwards-utc-85001-0622; Product Documentation Link: https://myeddie.edwardsutcfs.com/Media/Catalog%20Sheets/E85001-0646%20--%20Intelligent%20Smoke%20Detector.pdf; Product Page URL: https://myeddie.edwardsutcfs.com/Products/ProductSearch?SearchTerm=SIGA-PD; Product url: http://edwardsfiresafety.com/; Produttore: UTC Climate, Controls & Security; Provide Feedback: https://www.surveymonkey.com/s/XQB9QDX; Technical description: http://edwards-es.com/Data%20Sheets/8%20--%20Intelligent%20Initiating/E85001-0622%20--%20Intelligent%20Carbon%20Monoxide%20Detector.pdf; Titolo OmniClass: Fire Detection, Monitoring and Alarm; URL: http://www.edwardsfiresafety.com/
Type - Dimensioni - Base Depth: 0.018796 m; Base Diameter: 0.112014 m; Below Surface Depth: 0 m; Detector Depth: 0.0588264 m; Detector Diameter: 0.109195 m
Type - Elettrico - Operating Current: 0.000032 A; Operating Voltage: 19.95 V
Type - Generale - Brand url: http://www.edwardsfiresafety.com/; Date of publishing: 7/3/2013; Design country: United States; Edition number: 1; Manufacturer country: China; Manufacturer name: Edwards UTC; Nominal height: 0 m; Nominal width: 0 m; Product family: Electronics; Product group: Fire/Smoke Detectors; Product SKU: edwards-utc-85001-0622; QR code: http://bimobject.com/edwardsutc/product/edwards-utc-85001-0622; Region North America: US; Weight Net (Kg): 0
Type - Materiali e finiture - Housing Material: High Impact Polymer - UTC - White; Material main: Plastic
Type - Proprietà modello - Base Option: SIGA-SB; Detector is for Candadian Markets: no; Detector Option: Photo
Type - Strutturale - Weight: 0.00266893 kN
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_RivelatoreCo
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_RivelatoreCo
Type - Pset_ManufacturerTypeInformation - Manufacturer: UTC Climate, Controls & Security
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors: DFA_I_RivelatoreCo; Famiglia e tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors: DFA_I_RivelatoreCo; ID tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors: DFA_I_RivelatoreCo; Tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors: DFA_I_RivelatoreCo
Dati identità - Part Description: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Part Number: SIGA-PD w/ SIGA-SB base
Dimensioni - Volume: 0.000566744 m3
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Host: Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
Name (Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors:DFA_I_RivelatoreCo:...) | Contrassegno | Quota altimetrica da livello (m)
9000033 | 1991 | 2.5
9000157 | 1992 | 2.6
9000297 | 1994 | 2.5
9000413 | 1995 | 2.5
9000432 | 1996 | 2.6
9000440 | 1997 | 2.5
9000518 | 1998 | 2.6
9000530 | 1999 | 2.6
9000540 | 2000 | 2.6
9000548 | 2001 | 2.6
9000556 | 2002 | 2.6
9000566 | 2003 | 2.6
9000576 | 2004 | 2.6
9000592 | 2005 | 2.6

# IfcAlarm: Fire_Alarm-Intelligent_Detector-EDWARDS-Smoke_and_Heat_Detectors:DFA_I_RivelatoreFumiControsoffitto (161)
Type - Classification: D5030700 Fire Alarm Systems (Uniformat); Material: High Impact Polymer - UTC - White
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Fire_Alarm-Intelligent_Detector-EDWARDS-Smoke_and_Heat_Detectors
Type - Dati - Agency Listings: CAN/ULC-S529, UL 268, UL 268A; Alarm Point: Analyzes data from the sensing chamber to determine whether to alarm; Environmental Compensation: Automatic; Mounting Information: Plug-in, Maximum 12 in (305mm) from ceiling; Spacing: N/A; Storage and Operating Environment: Air Velocity: 0 to 4000 ft/min (0 to 20 m/s); Operating Temperature: 32°F to 120°F (0°C to 49°C); Storage Temperature: -4°F to 140°F (-20°C to 60°C); Humidity: 0 to 93% RH, Non-Condensing
Type - Dati identità - Codice assieme: D5030700; Commenti sul tipo: Rivelazione fumi; Copyright: Copyright © UTC Climate, Controls & Security; Date Last Modified: November 16, 2017; Descrizione: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Descrizione assieme: Fire Alarm Systems; Equipment Abbreviation: FS; Family Version: 1.0.0; Model Disclaimer: Contact UTC Climate, Controls & Security for more information.; Modello: SIGA-PD w/ SIGA-SB base; Nome del tipo: DFA_I_RivelatoreFumiControsoffitto; Numero OmniClass: 23.85.30.21.11; Original Creation Date: November 16, 2017; Product data url: https://bimobject.com/edwardsutc/product/edwards-utc-85001-0269; Product Documentation Link: https://myeddie.edwardsutcfs.com/Media/Catalog%20Sheets/E85001-0646%20--%20Intelligent%20Smoke%20Detector.pdf; Product Page URL: https://myeddie.edwardsutcfs.com/Products/ProductSearch?SearchTerm=SIGA-PD; Product url: http://edwardsfiresafety.com/; Produttore: UTC Climate, Controls & Security; Provide Feedback: https://www.surveymonkey.com/s/XQB9QDX; Technical description: http://edwards-es.com/Data%20Sheets/8%20--%20Intelligent%20Initiating/E85001-0269%20--%20Intelligent%20PS%20Detector.pdf; Titolo OmniClass: Fire Detection, Monitoring and Alarm; URL: http://www.edwardsfiresafety.com/
Type - Dimensioni - Below Surface Depth: 0 m; Base Depth: 0.018796 m; Base Diameter: 0.112014 m; Detector Depth: 0.0588264 m; Detector Diameter: 0.109195 m
Type - Elettrico - Operating Current: 0.000032 A; Operating Voltage: 19.95 V
Type - Generale - Edition number: 1; Nominal height: 0 m; Nominal width: 0 m; Brand url: http://www.edwardsfiresafety.com/; Date of publishing: 7/3/2013; Design country: United States; Manufacturer country: China; Manufacturer name: Edwards UTC; Product family: Electronics; Product group: Fire/Smoke Detectors; Product SKU: edwards-utc-85001-0269; QR code: http://bimobject.com/edwardsutc/product/edwards-utc-85001-0269; Region North America: US; Weight Net (Kg): 0
Type - Materiali e finiture - Housing Material: High Impact Polymer - UTC - White; Material main: Plastic
Type - Proprietà modello - Base Option: SIGA-SB; Detector is for Candadian Markets: no; Detector Option: Photo
Type - Strutturale - Weight: 0.00266893 kN
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_RivelatoreFumiControsoffitto
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_RivelatoreFumiControsoffitto
Type - Pset_ManufacturerTypeInformation - Manufacturer: UTC Climate, Controls & Security
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Fire_Alarm-Intelligent_Detector-EDWARDS-Smoke_and_Heat_Detectors: DFA_I_RivelatoreFumiControsoffitto; Famiglia e tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-Smoke_and_Heat_Detectors: DFA_I_RivelatoreFumiControsoffitto; ID tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-Smoke_and_Heat_Detectors: DFA_I_RivelatoreFumiControsoffitto; Tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-Smoke_and_Heat_Detectors: DFA_I_RivelatoreFumiControsoffitto
Dati identità - Part Description: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Part Number: SIGA-PD w/ SIGA-SB base
Dimensioni - Volume: 0.000566744 m3
Fasi - Fase di creazione: Nuova costruzione
Name (Fire_Alarm-Intelligent_Detector-EDWARDS-Smoke_and_Heat_Detectors:DFA_I_RivelatoreFumiControsoffitto:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9000253 | L00 - Piano Terra Piazza ELETTRICO | 1993 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9000938 | L00 - Piano Terra Piazza ELETTRICO | 2006 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9000947 | L00 - Piano Terra Piazza ELETTRICO | 2007 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9001095 | B01 - Piano Interrato ELETTRICO | 2010 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.04
9001119 | B01 - Piano Interrato ELETTRICO | 2011 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.299
9001786 | L00 - Piano Terra Piazza ELETTRICO | 2014 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9001788 | L00 - Piano Terra Piazza ELETTRICO | 2015 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9001789 | L00 - Piano Terra Piazza ELETTRICO | 2016 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002192 | L00 - Piano Terra Piazza ELETTRICO | 2032 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002203 | L00 - Piano Terra Piazza ELETTRICO | 2033 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002251 | L00 - Piano Terra Piazza ELETTRICO | 2034 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002447 | L00 - Piano Terra Piazza ELETTRICO | 2035 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002457 | L00 - Piano Terra Piazza ELETTRICO | 2036 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002465 | L00 - Piano Terra Piazza ELETTRICO | 2037 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002473 | L00 - Piano Terra Piazza ELETTRICO | 2038 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9002511 | L00 - Piano Terra Piazza ELETTRICO | 2041 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4
9002525 | L00 - Piano Terra Piazza ELETTRICO | 2042 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4
9002549 | L00 - Piano Terra Piazza ELETTRICO | 2043 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4
9002926 | L00 - Piano Terra Piazza ELETTRICO | 2044 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9003102 | L00 - Piano Terra Piazza ELETTRICO | 2046 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9003136 | L00 - Piano Terra Piazza ELETTRICO | 2047 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4
9003299 | L00 - Piano Terra Piazza ELETTRICO | 2049 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9003315 | L00 - Piano Terra Piazza ELETTRICO | 2051 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9003597 | L00 - Piano Terra Piazza ELETTRICO | 2052 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9003674 | L00 - Piano Terra Piazza ELETTRICO | 2053 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9003676 | L00 - Piano Terra Piazza ELETTRICO | 2054 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9004685 | L00 - Piano Terra Piazza ELETTRICO | 2064 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9004700 | L00 - Piano Terra Piazza ELETTRICO | 2065 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9004712 | L00 - Piano Terra Piazza ELETTRICO | 2066 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9004768 | L00 - Piano Terra Piazza ELETTRICO | 2068 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9005226 | L00 - Piano Terra Piazza ELETTRICO | 2069 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005742 | L00 - Piano Terra Piazza ELETTRICO | 2078 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005813 | L00 - Piano Terra Piazza ELETTRICO | 2079 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005821 | L00 - Piano Terra Piazza ELETTRICO | 2080 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005829 | L00 - Piano Terra Piazza ELETTRICO | 2081 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005837 | L00 - Piano Terra Piazza ELETTRICO | 2082 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005847 | L00 - Piano Terra Piazza ELETTRICO | 2083 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005855 | L00 - Piano Terra Piazza ELETTRICO | 2084 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005865 | L00 - Piano Terra Piazza ELETTRICO | 2085 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005877 | L00 - Piano Terra Piazza ELETTRICO | 2086 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005943 | L00 - Piano Terra Piazza ELETTRICO | 2087 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9005959 | L00 - Piano Terra Piazza ELETTRICO | 2088 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9006064 | L00 - Piano Terra Piazza ELETTRICO | 2091 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9006101 | L00 - Piano Terra Piazza ELETTRICO | 2093 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9006110 | L00 - Piano Terra Piazza ELETTRICO | 2095 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9006119 | L00 - Piano Terra Piazza ELETTRICO | 2097 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9006603 | L00 - Piano Terra Piazza ELETTRICO | 2102 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9007860 | L00 - Piano Terra Piazza ELETTRICO | 2104 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9007882 | L00 - Piano Terra Piazza ELETTRICO | 2105 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9008085 | L00 - Piano Terra Piazza ELETTRICO | 2111 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9008094 | L00 - Piano Terra Piazza ELETTRICO | 2113 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9008103 | L00 - Piano Terra Piazza ELETTRICO | 2115 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 4
9008114 | L00 - Piano Terra Piazza ELETTRICO | 2117 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 4
9008756 | L00 - Piano Terra Piazza ELETTRICO | 2123 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9009222 | L00 - Piano Terra Piazza ELETTRICO | 2132 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009230 | L00 - Piano Terra Piazza ELETTRICO | 2133 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009240 | L00 - Piano Terra Piazza ELETTRICO | 2134 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009250 | L00 - Piano Terra Piazza ELETTRICO | 2135 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009631 | L00 - Piano Terra Piazza ELETTRICO | 2137 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009754 | L00 - Piano Terra Piazza ELETTRICO | 2138 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009796 | L00 - Piano Terra Piazza ELETTRICO | 2140 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009814 | L00 - Piano Terra Piazza ELETTRICO | 2143 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009825 | L00 - Piano Terra Piazza ELETTRICO | 2145 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009834 | L00 - Piano Terra Piazza ELETTRICO | 2147 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009843 | L00 - Piano Terra Piazza ELETTRICO | 2149 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010107 | L00 - Piano Terra Piazza ELETTRICO | 2155 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010682 | L00 - Piano Terra Piazza ELETTRICO | 2157 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010729 | L00 - Piano Terra Piazza ELETTRICO | 2159 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010738 | L00 - Piano Terra Piazza ELETTRICO | 2161 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010747 | L00 - Piano Terra Piazza ELETTRICO | 2163 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010756 | L00 - Piano Terra Piazza ELETTRICO | 2165 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010765 | L00 - Piano Terra Piazza ELETTRICO | 2167 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010774 | L00 - Piano Terra Piazza ELETTRICO | 2169 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010783 | L00 - Piano Terra Piazza ELETTRICO | 2171 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010792 | L00 - Piano Terra Piazza ELETTRICO | 2173 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010808 | L00 - Piano Terra Piazza ELETTRICO | 2177 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010864 | L00 - Piano Terra Piazza ELETTRICO | 2179 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010892 | L00 - Piano Terra Piazza ELETTRICO | 2181 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010903 | L00 - Piano Terra Piazza ELETTRICO | 2183 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9010954 | L00 - Piano Terra Piazza ELETTRICO | 2184 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011038 | L00 - Piano Terra Piazza ELETTRICO | 2187 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011271 | L00 - Piano Terra Piazza ELETTRICO | 2196 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9011281 | L00 - Piano Terra Piazza ELETTRICO | 2197 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9011480 | L00 - Piano Terra Piazza ELETTRICO | 2211 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011488 | L00 - Piano Terra Piazza ELETTRICO | 2212 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011496 | L00 - Piano Terra Piazza ELETTRICO | 2213 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011508 | L00 - Piano Terra Piazza ELETTRICO | 2214 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011518 | L00 - Piano Terra Piazza ELETTRICO | 2215 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011526 | L00 - Piano Terra Piazza ELETTRICO | 2216 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011536 | L00 - Piano Terra Piazza ELETTRICO | 2217 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011546 | L00 - Piano Terra Piazza ELETTRICO | 2218 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9011554 | L00 - Piano Terra Piazza ELETTRICO | 2219 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9012961 | L00 - Piano Terra Piazza ELETTRICO | 2224 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9012969 | L00 - Piano Terra Piazza ELETTRICO | 2225 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9013452 | L00 - Piano Terra Piazza ELETTRICO | 2227 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9013750 | L00 - Piano Terra Piazza ELETTRICO | 2231 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9013776 | L00 - Piano Terra Piazza ELETTRICO | 2232 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9013866 | L00 - Piano Terra Piazza ELETTRICO | 2236 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9014084 | L00 - Piano Terra Piazza ELETTRICO | 2240 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9014106 | L00 - Piano Terra Piazza ELETTRICO | 2241 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9014621 | L02 - Piano Secondo ELETTRICO | 2242 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015127 | L02 - Piano Secondo ELETTRICO | 2258 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015139 | L02 - Piano Secondo ELETTRICO | 2259 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015151 | L02 - Piano Secondo ELETTRICO | 2260 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015165 | L02 - Piano Secondo ELETTRICO | 2261 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015180 | L02 - Piano Secondo ELETTRICO | 2262 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015190 | L02 - Piano Secondo ELETTRICO | 2263 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015202 | L02 - Piano Secondo ELETTRICO | 2264 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015219 | L02 - Piano Secondo ELETTRICO | 2265 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015243 | L02 - Piano Secondo ELETTRICO | 2266 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015258 | L02 - Piano Secondo ELETTRICO | 2267 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015274 | L02 - Piano Secondo ELETTRICO | 2268 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015299 | L02 - Piano Secondo ELETTRICO | 2269 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015324 | L02 - Piano Secondo ELETTRICO | 2270 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015675 | L02 - Piano Secondo ELETTRICO | 2271 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015734 | L02 - Piano Secondo ELETTRICO | 2273 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015743 | L02 - Piano Secondo ELETTRICO | 2275 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015754 | L02 - Piano Secondo ELETTRICO | 2277 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015765 | L02 - Piano Secondo ELETTRICO | 2279 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9015778 | L02 - Piano Secondo ELETTRICO | 2281 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9015787 | L02 - Piano Secondo ELETTRICO | 2283 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9015800 | L02 - Piano Secondo ELETTRICO | 2285 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015811 | L02 - Piano Secondo ELETTRICO | 2287 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015822 | L02 - Piano Secondo ELETTRICO | 2289 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015831 | L02 - Piano Secondo ELETTRICO | 2291 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015842 | L02 - Piano Secondo ELETTRICO | 2293 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015853 | L02 - Piano Secondo ELETTRICO | 2295 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015862 | L02 - Piano Secondo ELETTRICO | 2297 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9015871 | L02 - Piano Secondo ELETTRICO | 2299 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016130 | L02 - Piano Secondo ELETTRICO | 2305 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016519 | L02 - Piano Secondo ELETTRICO | 2321 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016531 | L02 - Piano Secondo ELETTRICO | 2322 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016543 | L02 - Piano Secondo ELETTRICO | 2323 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016553 | L02 - Piano Secondo ELETTRICO | 2324 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016568 | L02 - Piano Secondo ELETTRICO | 2325 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016607 | L02 - Piano Secondo ELETTRICO | 2326 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016664 | L02 - Piano Secondo ELETTRICO | 2327 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016676 | L02 - Piano Secondo ELETTRICO | 2328 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016703 | L02 - Piano Secondo ELETTRICO | 2329 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016740 | L02 - Piano Secondo ELETTRICO | 2330 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016750 | L02 - Piano Secondo ELETTRICO | 2331 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016760 | L02 - Piano Secondo ELETTRICO | 2332 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016772 | L02 - Piano Secondo ELETTRICO | 2333 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9016782 | L02 - Piano Secondo ELETTRICO | 2334 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9017087 | L02 - Piano Secondo ELETTRICO | 2336 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9017123 | L02 - Piano Secondo ELETTRICO | 2337 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9017142 | L02 - Piano Secondo ELETTRICO | 2338 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9017181 | L02 - Piano Secondo ELETTRICO | 2339 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9017208 | L02 - Piano Secondo ELETTRICO | 2340 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9139938 | L00 - Piano Terra Piazza ELETTRICO | 2347 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9332912 | B01 - Piano Interrato ELETTRICO | 2440 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.04
9659190 | L00 - Piano Terra Piazza ELETTRICO | 2631 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
10483078 | B01 - Piano Interrato ELETTRICO | 2640 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.04
10483080 | B01 - Piano Interrato ELETTRICO | 2641 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.04
10483081 | B01 - Piano Interrato ELETTRICO | 2642 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.04
10717649 | B01 - Piano Interrato ELETTRICO | 2696 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
10717721 | L00 - Piano Terra Piazza ELETTRICO | 2697 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | -1
10717737 | L00 - Piano Terra Piazza ELETTRICO | 2698 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | -0.9
10717754 | L00 - Piano Terra Piazza ELETTRICO | 2699 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | -1
10717829 | L00 - Piano Terra Piazza ELETTRICO | 2700 | Livello: L00 - Piano Terra Piazza ELETTRICO | OVA (quadrate) : LFX_I_IguzziniMod._TipoOvaMod.46032 | -0.234115
10717949 | L00 - Piano Terra Piazza ELETTRICO | 2701 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.2

# IfcAlarm: Indicatore Remoto:DFA_I_Indicatore_Remoto (4)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Rosso
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Indicatore Remoto
Type - Dati identità - Commenti sul tipo: Rivelazione fumi; Nome del tipo: DFA_I_Indicatore_Remoto; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Dimensioni - Frutto_Altezza: 0.046 m; Frutto_Larghezza: 0.068 m; Placca_Altezza: 0.086 m; Placca_Larghezza: 0.122 m
Type - Elettrico - Load Classification: Altro; Switch Voltage: 230 V
Type - Vincoli - Prospetto di default: 0.33 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_Indicatore_Remoto
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_Indicatore_Remoto
Material: Rosso, Placca
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Indicatore Remoto: DFA_I_Indicatore_Remoto; Famiglia e tipo: Indicatore Remoto: DFA_I_Indicatore_Remoto; ID tipo: Indicatore Remoto: DFA_I_Indicatore_Remoto; Tipo: Indicatore Remoto: DFA_I_Indicatore_Remoto
Dimensioni - Volume: 0.0000012468 m3
Elettrico - Load: 500 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L01 - Piano Primo ELETTRICO; Livello abaco: Livello: L01 - Piano Primo ELETTRICO; Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 1.56187 m
Name (Indicatore Remoto:DFA_I_Indicatore_Remoto:...) | Contrassegno
9589011 | 2627
9589013 | 2628
9590106 | 2629
9590107 | 2630

# IfcAlarm: Serranda tagliafuoco:DFA_I_SerrandaTagliafuoco (37)
Type - Material: Placca
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Serranda tagliafuoco
Type - Dati identità - Commenti sul tipo: Rivelazione fumi; Label: GFCI; Nome del tipo: DFA_I_SerrandaTagliafuoco; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Dimensioni - Frutto_Altezza: 0.046 m; Frutto_Larghezza: 0.068 m; Placca_Altezza: 0.086 m; Placca_Larghezza: 0.122 m
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Vincoli - Prospetto di default: 0.33 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_SerrandaTagliafuoco
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_SerrandaTagliafuoco
Material: Placca, Metallo
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Serranda tagliafuoco: DFA_I_SerrandaTagliafuoco; Famiglia e tipo: Serranda tagliafuoco: DFA_I_SerrandaTagliafuoco; ID tipo: Serranda tagliafuoco: DFA_I_SerrandaTagliafuoco; Tipo: Serranda tagliafuoco: DFA_I_SerrandaTagliafuoco
Dimensioni - Volume: 0.000677614 m3
Elettrico - Load: 500 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: <non associato>
Name (Serranda tagliafuoco:DFA_I_SerrandaTagliafuoco:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Quota altimetrica da livello (m)
10558082 | L00 - Piano Terra Piazza ELETTRICO | 2643 | Livello: L01 - Piano Primo ELETTRICO | -0.2 | 3.29601
10558084 | L00 - Piano Terra Piazza ELETTRICO | 2644 | Livello: L01 - Piano Primo ELETTRICO | 0 | 4.0435
10558086 | L00 - Piano Terra Piazza ELETTRICO | 2645 | Livello: L01 - Piano Primo ELETTRICO | 0 | 4.0435
10558088 | L00 - Piano Terra Piazza ELETTRICO | 2646 | Livello: L01 - Piano Primo ELETTRICO | 0 | 4.0435
10558092 | L00 - Piano Terra Piazza ELETTRICO | 2648 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.6985
10558100 | L00 - Piano Terra Piazza ELETTRICO | 2652 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.7135
10558102 | L00 - Piano Terra Piazza ELETTRICO | 2653 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.7135
10558104 | L00 - Piano Terra Piazza ELETTRICO | 2654 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.71358
10558106 | L00 - Piano Terra Piazza ELETTRICO | 2655 | Livello: L01 - Piano Primo ELETTRICO | -0.28 | 3.6146
10558108 | L00 - Piano Terra Piazza ELETTRICO | 2656 | Livello: L01 - Piano Primo ELETTRICO | 0.353458 | 3.9766
10558110 | L00 - Piano Terra Piazza ELETTRICO | 2657 | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.1985 | 5.05562
10558112 | L00 - Piano Terra Piazza ELETTRICO | 2658 | Livello: L01 - Piano Primo ELETTRICO | -0.197452 | 4.33478
10558114 | B01 - Piano Interrato ELETTRICO | 2659 | Livello: B01 - Piano Interrato ELETTRICO | 0 | 2.5867
10558118 | L00 - Piano Terra Piazza ELETTRICO | 2661 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.15 | 4.53207
10558122 | L00 - Piano Terra Piazza ELETTRICO | 2663 | Livello: L01 - Piano Primo ELETTRICO | 1.17563 | 3.93943
10558124 | L00 - Piano Terra Piazza ELETTRICO | 2664 | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.1785 | 4.86989
10558131 | L00 - Piano Terra Piazza ELETTRICO | 2668 | Livello: L01 - Piano Primo ELETTRICO | 0.260099 | 4.55965
10558133 | L00 - Piano Terra Piazza ELETTRICO | 2669 | Livello: L01 - Piano Primo ELETTRICO | -0.183356 | 4.66466
10558137 | L00 - Piano Terra Piazza ELETTRICO | 2671 | Livello: L01 - Piano Primo ELETTRICO | 0.18441 | 4.57866
10558139 | L02 - Piano Secondo ELETTRICO | 2672 | Livello: L02 - Piano Secondo ELETTRICO | 0.206589 | 3.82686
10558149 | L02 - Piano Secondo ELETTRICO | 2677 | Livello: L02 - Piano Secondo ELETTRICO | 0.181501 | 4.10044
10558151 | L02 - Piano Secondo ELETTRICO | 2678 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 3.83904
10558153 | L02 - Piano Secondo ELETTRICO | 2679 | Livello: L02 - Piano Secondo ELETTRICO | -0.0282843 | 3.8679
10558155 | L00 - Piano Terra Piazza ELETTRICO | 2680 | Livello: L01 - Piano Primo ELETTRICO | 0.610379 | 4.57866
10558278 | L00 - Piano Terra Piazza ELETTRICO | 2682 | Livello: L01 - Piano Primo ELETTRICO | 0.430084 | 3.93943
10558353 | L00 - Piano Terra Piazza ELETTRICO | 2683 | Livello: L01 - Piano Primo ELETTRICO | 0.830681 | 4.55965
10558456 | L00 - Piano Terra Piazza ELETTRICO | 2684 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.6985
10558465 | L00 - Piano Terra Piazza ELETTRICO | 2685 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.6985
10558499 | L00 - Piano Terra Piazza ELETTRICO | 2686 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.6985
10558507 | L00 - Piano Terra Piazza ELETTRICO | 2687 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4.6985
10558562 | L00 - Piano Terra Piazza ELETTRICO | 2688 | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.589388 | 4.86989
10558569 | L00 - Piano Terra Piazza ELETTRICO | 2689 | Livello: L00 - Piano Terra Piazza ELETTRICO | -1.00079 | 4.86989
10558642 | L00 - Piano Terra Piazza ELETTRICO | 2690 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.530528 | 4.53207
10558730 | L02 - Piano Secondo ELETTRICO | 2691 | Livello: L02 - Piano Secondo ELETTRICO | 1.4015 | 4.10044
10558737 | L02 - Piano Secondo ELETTRICO | 2692 | Livello: L02 - Piano Secondo ELETTRICO | 1.00888 | 4.10044
10558743 | L02 - Piano Secondo ELETTRICO | 2693 | Livello: L02 - Piano Secondo ELETTRICO | 0.592901 | 4.10044
10558811 | L02 - Piano Secondo ELETTRICO | 2694 | Livello: L02 - Piano Secondo ELETTRICO | 0.207819 | 3.82686

# IfcAlarm: rilevatore di fumi dentro pavimento:Rivelatori dentro pavimento (4)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Classification: D5030700 Fire Alarm Systems (Uniformat); Material: High Impact Polymer - UTC - White
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: rilevatore di fumi dentro pavimento
Type - Dati - Agency Listings: CAN/ULC-S529, UL 268, UL 268A; Alarm Point: Analyzes data from the sensing chamber to determine whether to alarm; Environmental Compensation: Automatic; Mounting Information: Plug-in, Maximum 12 in (305mm) from ceiling; Spacing: N/A; Storage and Operating Environment: Air Velocity: 0 to 4000 ft/min (0 to 20 m/s); Operating Temperature: 32°F to 120°F (0°C to 49°C); Storage Temperature: -4°F to 140°F (-20°C to 60°C); Humidity: 0 to 93% RH, Non-Condensing
Type - Dati identità - Codice assieme: D5030700; Commenti sul tipo: Rivelazione fumi; Copyright: Copyright © UTC Climate, Controls & Security; Date Last Modified: November 16, 2017; Descrizione: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Descrizione assieme: Fire Alarm Systems; Equipment Abbreviation: FS; Family Version: 1.0.0; Model Disclaimer: Contact UTC Climate, Controls & Security for more information.; Modello: SIGA-PD w/ SIGA-SB base; Nome del tipo: Rivelatori dentro pavimento; Numero OmniClass: 23.85.30.21.11; Original Creation Date: November 16, 2017; Product data url: https://bimobject.com/edwardsutc/product/edwards-utc-85001-0269; Product Documentation Link: https://myeddie.edwardsutcfs.com/Media/Catalog%20Sheets/E85001-0646%20--%20Intelligent%20Smoke%20Detector.pdf; Product Page URL: https://myeddie.edwardsutcfs.com/Products/ProductSearch?SearchTerm=SIGA-PD; Product url: http://edwardsfiresafety.com/; Produttore: UTC Climate, Controls & Security; Provide Feedback: https://www.surveymonkey.com/s/XQB9QDX; Technical description: http://edwards-es.com/Data%20Sheets/8%20--%20Intelligent%20Initiating/E85001-0269%20--%20Intelligent%20PS%20Detector.pdf; Titolo OmniClass: Fire Detection, Monitoring and Alarm; URL: http://www.edwardsfiresafety.com/
Type - Dimensioni - Below Surface Depth: 0 m; Base Depth: 0.018796 m; Base Diameter: 0.112014 m; Detector Depth: 0.0588264 m; Detector Diameter: 0.109195 m
Type - Elettrico - Operating Current: 0.000032 A; Operating Voltage: 19.95 V
Type - Generale - Edition number: 1; Nominal height: 0 m; Nominal width: 0 m; Brand url: http://www.edwardsfiresafety.com/; Date of publishing: 7/3/2013; Design country: United States; Manufacturer country: China; Manufacturer name: Edwards UTC; Product family: Electronics; Product group: Fire/Smoke Detectors; Product SKU: edwards-utc-85001-0269; QR code: http://bimobject.com/edwardsutc/product/edwards-utc-85001-0269; Region North America: US; Weight Net (Kg): 0
Type - Materiali e finiture - Housing Material: High Impact Polymer - UTC - White; Material main: Plastic
Type - Proprietà modello - Base Option: SIGA-SB; Detector is for Candadian Markets: no; Detector Option: Photo
Type - Strutturale - Weight: 0.00266893 kN
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_AlarmTypeCommon - Reference: Rivelatori dentro pavimento
Type - Pset_EnvironmentalImpactIndicators - Reference: Rivelatori dentro pavimento
Type - Pset_ManufacturerTypeInformation - Manufacturer: UTC Climate, Controls & Security
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: rilevatore di fumi dentro pavimento: Rivelatori dentro pavimento; Famiglia e tipo: rilevatore di fumi dentro pavimento: Rivelatori dentro pavimento; ID tipo: rilevatore di fumi dentro pavimento: Rivelatori dentro pavimento; Tipo: rilevatore di fumi dentro pavimento: Rivelatori dentro pavimento
Dati identità - Part Description: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Part Number: SIGA-PD w/ SIGA-SB base
Dimensioni - Volume: 0.000566744 m3
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L01 - Piano Primo ELETTRICO; Livello abaco: Livello: L01 - Piano Primo ELETTRICO; Quota altimetrica da livello: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
Name (rilevatore di fumi dentro pavimento:Rivelatori dentro pavimento:...) | Contrassegno
9587900 | 2372
9587905 | 2437
9587906 | 2438
9587907 | 2439

# IfcBuildingElementProxy: 04 - Unel doppia:EFX_I_UnelDoppia (150)
Type - Material: Frutto
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: 04 - Unel doppia
Type - Dati identità - Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_UnelDoppia; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Dimensioni - Frutto_Altezza: 0.046 m; Frutto_Larghezza: 0.068 m; Placca_Altezza: 0.086 m; Placca_Larghezza: 0.122 m
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 0.23 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_UnelDoppia
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_UnelDoppia
Material: Frutto, Placca
Altro - Famiglia: 04 - Unel doppia: EFX_I_UnelDoppia; Famiglia e tipo: 04 - Unel doppia: EFX_I_UnelDoppia; ID tipo: 04 - Unel doppia: EFX_I_UnelDoppia; Tipo: 04 - Unel doppia: EFX_I_UnelDoppia
Dimensioni - Area: 0.0301996 m2; Volume: 0.00021109 m3
Elettrico - Load: 500 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Name (04 - Unel doppia:EFX_I_UnelDoppia:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
8724620 | L00 - Piano Terra Piazza ELETTRICO | 3688 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8724700 | L00 - Piano Terra Piazza ELETTRICO | 3689 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8781230 | L00 - Piano Terra Piazza ELETTRICO | 3690 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8782309 | L00 - Piano Terra Piazza ELETTRICO | 3708 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8782368 | L00 - Piano Terra Piazza ELETTRICO | 3709 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8782404 | L00 - Piano Terra Piazza ELETTRICO | 3710 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8782630 | L00 - Piano Terra Piazza ELETTRICO | 3711 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8782713 | L00 - Piano Terra Piazza ELETTRICO | 3712 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8782805 | L00 - Piano Terra Piazza ELETTRICO | 3713 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.393
8782928 | L00 - Piano Terra Piazza ELETTRICO | 3714 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8783027 | L00 - Piano Terra Piazza ELETTRICO | 3715 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8832106 | L00 - Piano Terra Piazza ELETTRICO | 3786 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8832115 | L00 - Piano Terra Piazza ELETTRICO | 3787 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8832406 | L00 - Piano Terra Piazza ELETTRICO | 3788 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8832542 | L00 - Piano Terra Piazza ELETTRICO | 3789 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8832634 | L00 - Piano Terra Piazza ELETTRICO | 3791 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8833005 | L00 - Piano Terra Piazza ELETTRICO | 3792 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8833125 | L00 - Piano Terra Piazza ELETTRICO | 3793 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8962902 | L00 - Piano Terra Piazza ELETTRICO | 3803 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8962923 | L00 - Piano Terra Piazza ELETTRICO | 3804 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8963097 | L00 - Piano Terra Piazza ELETTRICO | 3805 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8963421 | L00 - Piano Terra Piazza ELETTRICO | 3806 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8963712 | L00 - Piano Terra Piazza ELETTRICO | 3807 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8963808 | L00 - Piano Terra Piazza ELETTRICO | 3808 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8963922 | L00 - Piano Terra Piazza ELETTRICO | 3809 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8964034 | L00 - Piano Terra Piazza ELETTRICO | 3810 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8964329 | L00 - Piano Terra Piazza ELETTRICO | 3811 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8964480 | L00 - Piano Terra Piazza ELETTRICO | 3812 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8964677 | L00 - Piano Terra Piazza ELETTRICO | 3813 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8964833 | L00 - Piano Terra Piazza ELETTRICO | 3814 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
8965393 | L00 - Piano Terra Piazza ELETTRICO | 3815 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.393
