Properties of the parts of a building model (IFC4), part 11 of 23

# IfcDistributionPort (6164)
Name
2 x Port_9505211
2 x Port_9505219
2 x Port_9505229
2 x Port_9505239
2 x Port_9505249
2 x Port_9505300
2 x Port_9505314
2 x Port_9505324
2 x Port_9505332
2 x Port_9505342
2 x Port_9505504
2 x Port_9505548
2 x Port_9505576
2 x Port_9505577
2 x Port_9505587
2 x Port_9505588
2 x Port_9505623
2 x Port_9505624
2 x Port_9505632
2 x Port_9505633
2 x Port_9505641
2 x Port_9505642
2 x Port_9505664
2 x Port_9505674
2 x Port_9505682
2 x Port_9505692
2 x Port_9505774
2 x Port_9505850
2 x Port_9505877
2 x Port_9505954
2 x Port_9506080
2 x Port_9506119
2 x Port_9506127
2 x Port_9506135
2 x Port_9506145
2 x Port_9506153
2 x Port_9506161
2 x Port_9506169
2 x Port_9506180
2 x Port_9506188
2 x Port_9506202
2 x Port_9506210
2 x Port_9506222
2 x Port_9506260
2 x Port_9506273
2 x Port_9506283
2 x Port_9506291
2 x Port_9506301
2 x Port_9506315
2 x Port_9506321
2 x Port_9506329
2 x Port_9506337
2 x Port_9506345
2 x Port_9506355
2 x Port_9506367
2 x Port_9506377
2 x Port_9506385
2 x Port_9506395
2 x Port_9506405
2 x Port_9506415
2 x Port_9506423
2 x Port_9506433
2 x Port_9506441
2 x Port_9506449
2 x Port_9506457
2 x Port_9506465
2 x Port_9506473
2 x Port_9506507
2 x Port_9506540
2 x Port_9506580
2 x Port_9506588
2 x Port_9506596
2 x Port_9506604
2 x Port_9506612
2 x Port_9506620
2 x Port_9506630
2 x Port_9506640
2 x Port_9506651
2 x Port_9506660
2 x Port_9506733
2 x Port_9506741
2 x Port_9506774
2 x Port_9506808
2 x Port_9506816
2 x Port_9506824
2 x Port_9506832
2 x Port_9506840
Port_9506864
Port_9506941
2 x Port_9507000
2 x Port_9507034
2 x Port_9507071
2 x Port_9507122
2 x Port_9507163
2 x Port_9507173
2 x Port_9507183
2 x Port_9507225
2 x Port_9507259
2 x Port_9507270
Port_9507304
Port_9507323
2 x Port_9507380
2 x Port_9507419
2 x Port_9507421
2 x Port_9507496
2 x Port_9507652
2 x Port_9507691
2 x Port_9507721
2 x Port_9507729
2 x Port_9507741
2 x Port_9507749
2 x Port_9507759
2 x Port_9507769
2 x Port_9507781
2 x Port_9507799
2 x Port_9507935
2 x Port_9507973
2 x Port_9507983
2 x Port_9508047
2 x Port_9508057
2 x Port_9508099
2 x Port_9508137
2 x Port_9508146
2 x Port_9508154
2 x Port_9508464
2 x Port_9508985
2 x Port_9509017
2 x Port_9509158
2 x Port_9509160
Port_9509231
Port_9509249
2 x Port_9509292
2 x Port_9509333
Port_9509357
Port_9509379
Port_9509399
Port_9510544
Port_9510546
Port_9510640
Port_9514076
Port_9514168
Port_9514381
Port_9514455
Port_9514604
Port_9516352
Port_9516404
Port_9516455
Port_9516548
Port_9516613
Port_9516676
Port_9516710
Port_9516915
Port_9517013
Port_9517097
Port_9517104
Port_9517635
Port_9517672
Port_9517807
2 x Port_9518293
Port_9518546
Port_9518587
Port_9518612
Port_9518640
Port_9518821
Port_9518872
Port_9518917
Port_9518989
Port_9519029
Port_9519226
Port_9519274
2 x Port_9519535
2 x Port_9519614
2 x Port_9519630
Port_9519835
Port_9519981
Port_9519992
Port_9520008
Port_9520124
Port_9520280
Port_9520297
Port_9520405
Port_9520437
Port_9520447
Port_9520468
Port_9520535
Port_9520556
Port_9520582
Port_9520742
Port_9520815
Port_9520886
Port_9520912
Port_9520941
Port_9521022
Port_9521086
Port_9521122
Port_9521196
Port_9521257
Port_9521301
Port_9521452
Port_9521525
Port_9523001
Port_9523071
Port_9523104
Port_9523122
Port_9523152
Port_9523216
Port_9523256
Port_9523354
Port_9523356
Port_9523358
Port_9523359
Port_9523361
Port_9523562
Port_9523633
Port_9523680
Port_9523760
Port_9523807
Port_9523881
Port_9523925
Port_9524030
Port_9524053
Port_9524079
Port_9524196
Port_9524222
Port_9524245
Port_9524452
2 x Port_9535362
2 x Port_9540034
Port_9549156
Port_9549179
Port_9571372
Port_9583708
Port_9583741
Port_9584286
Port_9584369
Port_9584388
Port_9584415
Port_9584423
Port_9584431
Port_9584439
Port_9584449
Port_9584457
Port_9584467
Port_9584491
Port_9584542
Port_9584570
Port_9584604
Port_9584618
Port_9584632
Port_9584646
Port_9584658
Port_9584670
Port_9584680
Port_9584692
Port_9584939
Port_9587900
Port_9587905
Port_9587906
Port_9587907
Port_9589011
Port_9589013
Port_9590106
Port_9590107
Port_9594075
Port_9602180
Port_9602249
Port_9602328
Port_9602356
Port_9602404
Port_9602455
Port_9602527
Port_9602593
Port_9602660
Port_9602852
Port_9602906
Port_9607102
Port_9607103
Port_9607104
Port_9617303
Port_9617342
Port_9617343
Port_9617344
Port_9617345
Port_9617346
Port_9617347
Port_9617348
Port_9617349
Port_9617350
Port_9617351
Port_9617352
Port_9617353
Port_9617354
Port_9617355
Port_9622777
Port_9622788
Port_9622796
Port_9622806
Port_9622820
Port_9622830
Port_9622842
Port_9622850
Port_9622858
Port_9622868
Port_9622878
Port_9622888
Port_9622898
Port_9622906
Port_9652250
Port_9652257
Port_9652525
Port_9652577
Port_9658251
Port_9658325
Port_9658420
Port_9658492
Port_9658760
Port_9658848
Port_9658922
Port_9659171
Port_9659172
Port_9659174
Port_9659190
Port_9659209
Port_9659406
Port_9659427
Port_9659573
Port_9659662
Port_9659788
Port_9659974
Port_9660302
Port_9660445
Port_9660451
Port_9660547
Port_9660579
Port_9660673
Port_9660978
Port_9660998
Port_9661022
Port_9661109
Port_9661168
Port_9661409
Port_9661423
Port_9661627
Port_9661701
2 x Port_9662764
2 x Port_9662788
2 x Port_9662803
2 x Port_9662836
2 x Port_9662860
2 x Port_9662880
2 x Port_9662916
2 x Port_9662943
2 x Port_9662966
2 x Port_9662981
2 x Port_9662996
2 x Port_9663053
2 x Port_9663071
2 x Port_9663083
2 x Port_9663098
2 x Port_9663110
2 x Port_9663140
2 x Port_9663158
2 x Port_9663182
2 x Port_9663200
2 x Port_9663221
2 x Port_9663248
2 x Port_9663260
2 x Port_9663284
2 x Port_9663302
2 x Port_9663332
2 x Port_9663359
2 x Port_9663383
2 x Port_9663395
2 x Port_9663407
2 x Port_9663419
2 x Port_9663431
2 x Port_9663443
2 x Port_9663461
2 x Port_9663473
2 x Port_9663488
2 x Port_9663518
2 x Port_9663536
2 x Port_9663554
2 x Port_9663572
2 x Port_9663602
2 x Port_9663877
2 x Port_9663892
2 x Port_9663913
2 x Port_9663934
2 x Port_9663961
2 x Port_9664048
2 x Port_9664136
2 x Port_9664151
2 x Port_9664172
Port_9664398
Port_9664449
Port_9664471
Port_9664547
Port_9664602
Port_9664715
Port_9664820
Port_9664864
Port_9664932
Port_9665028
Port_9665073
Port_9665153
Port_9665278
Port_9665541
2 x Port_9675334
2 x Port_9685611
2 x Port_9685692
2 x Port_9685806
2 x Port_9685830
2 x Port_9686146
2 x Port_9686167
2 x Port_9686282
Port_9686327
Port_9686366
Port_9686439
Port_9686535
Port_9686629
Port_9687045
2 x Port_9687626
2 x Port_9687641
2 x Port_9687692
2 x Port_9687713
2 x Port_9687842
2 x Port_9688010
2 x Port_9688022
2 x Port_9688159
2 x Port_9688251
2 x Port_9688467
2 x Port_9688703
2 x Port_9688715
2 x Port_9688863
Port_9689147
2 x Port_9689217
2 x Port_9689397
2 x Port_9689611
2 x Port_9689626
2 x Port_9689681
2 x Port_9690031
2 x Port_9698838
2 x Port_9698839
2 x Port_9698840
Port_9698852
Port_9698853
Port_9698854
Port_9698855
2 x Port_9698858
2 x Port_9698860
2 x Port_9698861
2 x Port_9698864
Port_9699085
Port_9699086
Port_9699087
Port_9699088
Port_9699089
Port_9699090
Port_9699091
Port_9699092
Port_9699093
Port_9699094
Port_9699209
Port_9699210
Port_9699211
Port_9699212
Port_9699213
Port_9699214
Port_9699215
Port_9699216
Port_9699217
Port_9699218
Port_9699330
Port_9699361
Port_9699369
Port_9699381
Port_9699391
Port_9699401
Port_9699411
Port_9699419
Port_9699539
Port_9699613
Port_9699621
Port_9699631
Port_9699643
Port_9699653
Port_9699663
Port_9699673
Port_9699681
Port_9699693
Port_9699718
Port_9699719
Port_9699720
Port_9699721
Port_9699722
Port_9699723
Port_9699724
Port_9699725
Port_9699726
Port_9699727
Port_9700360
Port_9700361
Port_9700376
Port_9700377
Port_9700386
Port_9700387
Port_9700396
Port_9700397
Port_9700406
Port_9700407
Port_9700416
Port_9700417
Port_9700436
Port_9700437
Port_9700499
Port_9700500
Port_9700501
Port_9700502
Port_9700503
Port_9700504
Port_9700505
Port_9700506
Port_9700507
Port_9700508
Port_9700509
Port_9700510
Port_9700511
Port_9700512
Port_9700816
Port_9701015
Port_9701025
Port_9701033
Port_9701045
Port_9701055
Port_9701065
Port_9701075
Port_9701085
Port_9717510
Port_9717550
Port_9717558
Port_9717568
Port_9717600
Port_9717610
Port_9717620
Port_9717630
Port_9717640
Port_9717652
Port_9717684
Port_9717697
Port_9717732
Port_9717733
Port_9717741
Port_9717742
Port_9717750
Port_9717751
Port_9717759
Port_9717760
Port_9717770
Port_9717771
Port_9717781
Port_9717782
Port_9717790
Port_9717791
Port_9717799
Port_9717800
Port_9717808
Port_9717809
Port_9717823
Port_9717824
Port_9717832
Port_9717833
Port_9717841
Port_9717842
Port_9717850
Port_9717851
Port_9718058
Port_9718093
Port_9718177
Port_9718203
Port_9718335
Port_9718433
Port_9718468
Port_9718488
Port_9718502
Port_9718535
Port_9718594
Port_9718624
Port_9718675
Port_9718755
Port_9718776
Port_9718886
Port_9718963
Port_9718984
Port_9719022
Port_9719203
2 x Port_9719311
Port_9719352
Port_9719408
Port_9719478
Port_9719627
Port_9719651
Port_9719668
Port_9719693
Port_9719716
Port_9719742
Port_9719750
Port_9719762
Port_9719840
Port_9719850
Port_9719906
Port_9719944
Port_9719955
Port_9719990
2 x Port_9720056
2 x Port_9720084
2 x Port_9720092
2 x Port_9720100
2 x Port_9720148
Port_9720192
Port_9720281
Port_9720289
Port_9720299
Port_9720309
Port_9720331
Port_9720339
Port_9720349
Port_9720361
Port_9720371
Port_9720407
Port_9720584
Port_9721055
Port_9721209
Port_9721261
Port_9721271
Port_9721299
Port_9721407
Port_9721458
Port_9721512
Port_9721546
Port_9721586
Port_9721620
Port_9721660
Port_9721698
Port_9721741
Port_9721778
Port_9721792
Port_9721851
Port_9721871
Port_9721888
Port_9721934
Port_9721948
Port_9721987
Port_9722335
Port_9722372
Port_9722395
Port_9722430
Port_9722505
Port_9722559
Port_9722607
Port_9722608
Port_9722624
Port_9722641
Port_9722739
Port_9722769
Port_9722806
Port_9722820
Port_9722831
Port_9722842
Port_9723557
Port_9723755
Port_9723991
Port_9724015
Port_9724048
Port_9742958
Port_9743037
Port_9743054
Port_9743379
Port_9743796
Port_9744051
Port_9744265
Port_9744658
Port_9744718
Port_9744759
Port_9744991
Port_9745009
Port_9748303
Port_9748390
Port_9748418
Port_9749037
Port_9749224
Port_9749911
Port_9749922
Port_9749974
Port_9750024
Port_9750076
Port_9750114
Port_9750173
Port_9750201
Port_9750261
Port_9750367
Port_9750390
Port_9750434
Port_9750454
Port_9750483
Port_9750527
Port_9750547
Port_9750578
Port_9750600
Port_9750625
Port_9750675
Port_9750700
Port_9750711
Port_9750739
Port_9750771
Port_9750817
Port_9750860
Port_9750900
Port_9750933
Port_9751007
Port_9751270
Port_9751364
Port_9752012
Port_9752212
Port_9752284
Port_9752605
Port_9752802
Port_9753164
Port_9753184
Port_9753200
Port_9753203
Port_9753206
Port_9753222
Port_9753224
Port_9753226
Port_9753239
Port_9753241
Port_9753243
Port_9753274
Port_9753276
Port_9753278
Port_9753484
Port_9753530
Port_9753567
Port_9753568
Port_9753616
Port_9753617
Port_9753813
Port_9753820
Port_9753913
Port_9754173
Port_9754694
Port_9754776
Port_9754861
Port_9754963
Port_9755013
Port_9755057
Port_9755124
Port_9755188
Port_9755332
Port_9755333
Port_9755382
Port_9755403
Port_9755476
Port_9755477
Port_9755654
Port_9756111
Port_9756138
Port_9756807
Port_9757068
Port_9761504
Port_9761645
Port_9761791
Port_9764142
Port_9764321
Port_9764416
Port_9764614
Port_9764822
Port_9764877
Port_9765059
Port_9765109
Port_9765216
Port_9765233
Port_9765309
Port_9765347
Port_9765435
Port_9765476
Port_9765615
Port_9765847
Port_9765962
Port_9766016
Port_9804372
Port_9813120
Port_9813153
Port_9813425
Port_9885928
Port_9885966
Port_9891259
Port_9891382
Port_9891627
Port_9891732
Port_9891934
Port_9892052
Port_9892319
Port_9892557
2 x Port_9892796
2 x Port_9892797
Port_9892799
Port_9892801
Port_9892894
Port_9892896
Port_9892923
Port_10289424
Port_10290081
Port_10290102
Port_10290342
Port_10291392
Port_10291576
Port_10292201
Port_10292283
Port_10292298
Port_10292545
Port_10292564
Port_10292760
Port_10292797
Port_10294615
Port_10294651
Port_10294762
3 x Port_10294848
Port_10294956
Port_10295002
Port_10295065
Port_10295076
Port_10295410
Port_10295545
Port_10295771
Port_10296719
Port_10296739
Port_10296888
Port_10296902
Port_10297114
Port_10297230
Port_10297289
Port_10297307
Port_10297641
Port_10297793
Port_10297827
Port_10297857
Port_10297951
Port_10297973
Port_10297998
Port_10298024
Port_10298057
Port_10298110
Port_10298121
Port_10298346
Port_10298371
Port_10298400
Port_10299002
Port_10299058
Port_10299084
Port_10299143
Port_10299393
Port_10299731
Port_10299740
Port_10300017
Port_10300071
Port_10300123
Port_10300227
Port_10300243
Port_10300685
Port_10300749
Port_10300769
Port_10300993
Port_10301015
Port_10301268
Port_10301523
Port_10301628
Port_10301674
2 x Port_10301694
Port_10301983
Port_10302023
Port_10302061
Port_10302076
Port_10302285
Port_10302432
Port_10302490
Port_10302519
Port_10302766
Port_10302800
Port_10303115
Port_10303238
Port_10303258
Port_10303567
Port_10303577
Port_10303635
Port_10303687
Port_10303733
Port_10303746
Port_10303953
Port_10304083
Port_10304103
Port_10304234
Port_10304266
Port_10304328
Port_10304351
Port_10304452
Port_10304617
Port_10304974
Port_10305030
Port_10305070
Port_10305092
Port_10305337
Port_10305993
Port_10306012
Port_10307138
Port_10307157
Port_10307344
Port_10307470
Port_10307553
Port_10307567
Port_10307720
Port_10307734
Port_10307856
Port_10307871
Port_10307910
Port_10307955
Port_10308168
Port_10308192
Port_10308248
Port_10308445
Port_10308612
Port_10308752
Port_10308837
Port_10308838
Port_10308913
Port_10308914
Port_10308968
Port_10309011
Port_10309044
3 x Port_10309128
Port_10309239
Port_10309255
Port_10309631
Port_10309858
Port_10309979
Port_10310171
Port_10310333
Port_10310370
Port_10310381
Port_10310521
Port_10310628
Port_10310738
Port_10311375
Port_10311410
Port_10311545
Port_10311826
Port_10312020
Port_10312507
Port_10312569
Port_10312665
Port_10312702
Port_10312744
Port_10312791
Port_10312822
Port_10313098
Port_10313395
Port_10313505
Port_10313690
Port_10314034
Port_10314055
Port_10314209
Port_10314373
3 x Port_10314829
Port_10315039
Port_10315187
Port_10315246
Port_10315248
Port_10319325
Port_10319376
Port_10319451
Port_10319511
Port_10319826
Port_10319870
Port_10319983
Port_10319999
Port_10320317
Port_10320415
Port_10320438
Port_10320457
Port_10321813
Port_10321884
Port_10321896
Port_10324363
Port_10326524
Port_10326586
Port_10326632
Port_10326685
Port_10326725
Port_10326766
Port_10326803
Port_10326843
Port_10326896
Port_10326941
Port_10327001
Port_10327070
Port_10327112
Port_10327152
Port_10327203
Port_10327265
Port_10327311
Port_10327348
Port_10327389
Port_10327438
Port_10327468
Port_10327506
24 x Port_10343943
24 x Port_10344000
24 x Port_10344018
24 x Port_10344058
24 x Port_10344106
24 x Port_10344148
24 x Port_10344224
24 x Port_10344264
24 x Port_10344413
24 x Port_10344414
24 x Port_10344415
2 x Port_10344436
2 x Port_10344440
2 x Port_10344451
2 x Port_10344452
2 x Port_10344454
2 x Port_10344457
2 x Port_10344472
2 x Port_10344474
2 x Port_10344475
2 x Port_10344485
2 x Port_10344486
2 x Port_10344487
2 x Port_10344490
Port_10344493
Port_10344494
Port_10344495
Port_10344497
Port_10344498
Port_10344500
Port_10344505
Port_10344506
Port_10344507
Port_10344509
Port_10344516
Port_10344517
Port_10344518
Port_10350266
Port_10350448
Port_10350467
Port_10350608
Port_10350764
Port_10350984
Port_10351156
Port_10351325
Port_10351507
Port_10351622
Port_10351918
Port_10352163
Port_10352444
Port_10352733
Port_10353437
Port_10353451
Port_10353753
Port_10354167
Port_10354198
Port_10354635
Port_10354899
Port_10355207
Port_10355533
Port_10355803
Port_10356097
Port_10356470
Port_10356755
Port_10357142
Port_10357479
Port_10358348
Port_10358803
Port_10359301
Port_10359603
Port_10360041
Port_10360909
Port_10361096
Port_10361208
Port_10361408
Port_10361521
Port_10361659
Port_10361803
Port_10361954
Port_10362104
Port_10362234
Port_10362588
Port_10362637
Port_10362810
Port_10363270
Port_10363423
Port_10363779
Port_10364040
Port_10364282
Port_10364620
Port_10364836
Port_10365223
Port_10365750
Port_10365869
Port_10366226
Port_10366765
Port_10366804
Port_10367140
Port_10367556
Port_10368008
Port_10368672
Port_10369010
Port_10369300
Port_10369670
Port_10370063
Port_10370328
Port_10370614
Port_10370852
Port_10371155
Port_10371456
Port_10372357
Port_10372675
Port_10372704
Port_10372852
Port_10373412
Port_10373534
Port_10373708
Port_10373857
Port_10374007
Port_10375537
Port_10375578
Port_10375780
Port_10375928
Port_10376871
Port_10377066
Port_10377243
Port_10377711
Port_10378031
Port_10378289
Port_10396573
Port_10396574
Port_10396608
Port_10396609
Port_10396680
Port_10424536
Port_10424538
Port_10424539
Port_10424541
Port_10424542
Port_10424543
Port_10424544
Port_10424545
Port_10424546
Port_10424549
Port_10424550
Port_10424551
Port_10429120
Port_10429121
Port_10429122
Port_10429123
Port_10429124
Port_10429125
Port_10429126
Port_10429127
Port_10429140
Port_10429141
Port_10429142
Port_10429143
Port_10429144
Port_10429145
Port_10429146
Port_10429147
Port_10429148
Port_10429149
Port_10429150
Port_10429152
Port_10429153
Port_10429154
Port_10429155
Port_10429156
Port_10429159
Port_10429160
Port_10429161
Port_10429162
Port_10429267
Port_10429272
Port_10429273
Port_10429274
Port_10429275
Port_10429276
Port_10429277
Port_10429278
Port_10429279
Port_10429288
Port_10429314
Port_10429323
Port_10429324
Port_10429326
Port_10429327
Port_10429328
Port_10429330
Port_10429332
Port_10429340
Port_10429342
Port_10429344
Port_10429358
Port_10429359
Port_10429361
Port_10429363
Port_10429365
Port_10429367
Port_10429368
Port_10429372
Port_10429374
Port_10429376
Port_10429378
Port_10429380
Port_10429385
Port_10429387
Port_10429389
Port_10429390
Port_10429392
Port_10429394
Port_10429395
Port_10429397
Port_10429398
Port_10429431
Port_10429432
Port_10429433
Port_10429434
Port_10429435
Port_10429664
Port_10430208
Port_10430275
Port_10430402
Port_10430929
Port_10431088
Port_10433561
2 x Port_10433583
2 x Port_10433584
2 x Port_10433585
Port_10474347
Port_10474440
Port_10477482
Port_10477571
Port_10477656
Port_10477690
Port_10477776
Port_10477788
Port_10477815
Port_10478628
Port_10478732
Port_10478852
Port_10479068
Port_10479386
Port_10479784
Port_10479922
Port_10480069
Port_10482674
Port_10482827
Port_10482857
Port_10483078
Port_10483080
Port_10483081
3 x Port_10483082
2 x Port_10558082
2 x Port_10558084
2 x Port_10558086
2 x Port_10558088
2 x Port_10558092
2 x Port_10558100
2 x Port_10558102
2 x Port_10558104
2 x Port_10558106
2 x Port_10558108
2 x Port_10558110
2 x Port_10558112
2 x Port_10558114
2 x Port_10558118
2 x Port_10558122
2 x Port_10558124
2 x Port_10558131
2 x Port_10558133
2 x Port_10558137
2 x Port_10558139
2 x Port_10558149
2 x Port_10558151
2 x Port_10558153
2 x Port_10558155
2 x Port_10558278
2 x Port_10558353
2 x Port_10558456
2 x Port_10558465
2 x Port_10558499
2 x Port_10558507
2 x Port_10558562
2 x Port_10558569
2 x Port_10558642
2 x Port_10558730
2 x Port_10558737
2 x Port_10558743
2 x Port_10558811
3 x Port_10575350
3 x Port_10575395
2 x Port_10665047
3 x Port_10665530
2 x Port_10665997
2 x Port_10666004
Port_10666025
Port_10666186
Port_10666196
3 x Port_10666463
Port_10667524
Port_10691760
Port_10695412
Port_10695437
Port_10696015
Port_10696185
Port_10696276
Port_10709997
Port_10710014
Port_10710025
Port_10710037
Port_10710061
Port_10710073
Port_10710085
Port_10710236
Port_10710248
Port_10710260
Port_10710272
Port_10710284
Port_10710296
Port_10710307
Port_10710319
Port_10710336
Port_10710354
Port_10710366
Port_10710384
Port_10710396
Port_10710667
Port_10710668
Port_10710669
Port_10710671
Port_10710673
Port_10710675
Port_10710677
Port_10710679
Port_10710681
Port_10710683
Port_10710685
Port_10710687
Port_10710689
Port_10710690
Port_10710692
Port_10710693
Port_10710695
Port_10710697
Port_10710699
Port_10710701
Port_10710795
Port_10710796
Port_10710797
Port_10710798
Port_10710799
Port_10710800
Port_10710801
Port_10710802
Port_10710803
Port_10710804
Port_10710805
Port_10710806
Port_10710807
Port_10710808
Port_10710809
Port_10710810
Port_10710811
Port_10710812
Port_10710813
Port_10710814
Port_10717649
Port_10717721
Port_10717737
Port_10717754
Port_10717829
Port_10717949
Port_10734709
Port_10734832
Port_10734844
Port_10793328

# IfcElectricAppliance: Communication_Bosch_Horn_Loundspeaker_(Circular):DCA_I_DiffusoriEsterni (10)
Type - PredefinedType: USERDEFINED; Classification: E1010 Commercial Equipment (Uniformat); Material: HighImpactABS_RAL7035
Type - Altro - Categoria: Dispositivi di comunicazione; Material: ABS; ModelNumber: F.01U.304.394; Nome famiglia: Communication_Bosch_Horn_Loundspeaker_(Circular)
Type - Dati identità - ArchitectsAndEngineersSpecs: n/a; Codice assieme: E1010; Commenti sul tipo: Audio Evac; Costo: 0; Descrizione: Horn Loudspeaker 6 W, ABS IP 67 housing, high‑quality speech and music reproduction, IP67 water and dust protected, salt mist and chlorine resistant, EN 60945 certified, light grey RAL7035.; Descrizione assieme: Commercial Equipment; Disclaimer: http://resource.boschsecurity.com/information/BIM/Disclaimer.pdf; InstallationManual: http://resource.boschsecurity.us/documents/LH2_UC06_IN_Installation_Note_enUS_27021616760948619.pdf; Modello: n/a; Nome del tipo: DCA_I_DiffusoriEsterni; Nota chiave: n/a; Numero OmniClass: 23.85.10.11.14.14.14; PlanningTools: http://www.boschsecurity.com/corporate/products-and-services/digital-public-address-and-emergency-sound-mass-notification-systems/index.html; Product data url: https://bimobject.com/boschsecuritysystems/product/horn_loundspeaker; Produttore: Bosch Security Systems; RevitCategory: Communication Device; Titolo OmniClass: Loudspeakers; Uniclass2015Code: Ss_75_10_68_68 : Public address systems; URL: n/a
Type - Dimensioni - Diameter: 0.143 m; Length: 0.136 m
Type - Generale - ManufacturerURL: www.boschsecurity.com; ProductInformation: http://resource.boschsecurity.com/documents/LH2_UC06_Data_sheet_enUS_18014418153352203.pdf; Version: 1
Type - Grafica - LBC3482-00: no; LBC3483-00: no; LBC3484-00: no; LH2-UC06: yes; LH2-UC15E: no
Type - Materiali e finiture - MaterialRALColour: RAL 7035
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DCA_I_DiffusoriEsterni
Type - Pset_EnvironmentalImpactIndicators - Reference: DCA_I_DiffusoriEsterni
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security Systems
Type - Ifc - IfcExportAs: IfcElectricAppliance; IfcExportType: USERDEFINED
Material: HighImpactABS_RAL7035, Aluminum_RAL7035
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Communication_Bosch_Horn_Loundspeaker_(Circular): DCA_I_DiffusoriEsterni; Famiglia e tipo: Communication_Bosch_Horn_Loundspeaker_(Circular): DCA_I_DiffusoriEsterni; ID tipo: Communication_Bosch_Horn_Loundspeaker_(Circular): DCA_I_DiffusoriEsterni; Tipo: Communication_Bosch_Horn_Loundspeaker_(Circular): DCA_I_DiffusoriEsterni
Dimensioni - Angle: 0 deg; AngleControl: 0 deg; Area: 1.12084 m2; MaxAngle: 90 deg; MinAngle: -90 deg; Volume: 0.0812395 m3
Elettrico - Circuiti - Dati elettrici: 0 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Name (Communication_Bosch_Horn_Loundspeaker_(Circular):DCA_I_DiffusoriEsterni:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9158842 | B01 - Piano Interrato ELETTRICO | 594 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.9
9227198 | B01 - Piano Interrato ELETTRICO | 595 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.9
9227442 | B01 - Piano Interrato ELETTRICO | 596 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.1
9227651 | B01 - Piano Interrato ELETTRICO | 597 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.1
9227980 | B01 - Piano Interrato ELETTRICO | 598 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.1
9228069 | B01 - Piano Interrato ELETTRICO | 599 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.1
9228267 | B01 - Piano Interrato ELETTRICO | 600 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.9
9228428 | B01 - Piano Interrato ELETTRICO | 601 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.1
9228507 | B01 - Piano Interrato ELETTRICO | 602 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.1
9228628 | L00 - Piano Terra Piazza ELETTRICO | 603 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.5

# IfcElectricAppliance: Dati Torretta T0-17:EFX_I_TorrettaT0-17 (60)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Nome famiglia: Dati Torretta T0-17; Tipologia: 01 - Bipasso Singola
Type - Dati identità - Commenti sul tipo: DATI; Label: GFCI; Nome del tipo: EFX_I_TorrettaT0-17; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.55 m
Type - Pset_ElectricApplianceTypeCommon - Reference: EFX_I_TorrettaT0-17
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_TorrettaT0-17
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati Torretta T0-17: EFX_I_TorrettaT0-17; Famiglia e tipo: Dati Torretta T0-17: EFX_I_TorrettaT0-17; ID tipo: Dati Torretta T0-17: EFX_I_TorrettaT0-17; Tipo: Dati Torretta T0-17: EFX_I_TorrettaT0-17
Dimensioni - Area: 0.0194455 m2; Distanza_simbolo: 0.5 m; Volume: 0.00013181 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L01 - Piano Primo ELETTRICO; Livello abaco: Livello: L01 - Piano Primo ELETTRICO; Offset da host: 0 m; Quota altimetrica da livello: 0.113625 m
Name (Dati Torretta T0-17:EFX_I_TorrettaT0-17:...) | Contrassegno | Host
9430645 | 1216 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430752 | 1217 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430772 | 1218 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430853 | 1219 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430856 | 1220 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430859 | 1221 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430875 | 1222 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430878 | 1223 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430881 | 1224 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430897 | 1225 | <non associato>
9430900 | 1226 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430903 | 1227 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430923 | 1228 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9430926 | 1229 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431022 | 1230 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431025 | 1231 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431045 | 1232 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431048 | 1233 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431064 | 1234 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431067 | 1235 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431080 | 1236 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431083 | 1237 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431103 | 1238 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431106 | 1239 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431126 | 1240 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431129 | 1241 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431132 | 1242 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431135 | 1243 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431138 | 1244 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431141 | 1245 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431144 | 1246 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431147 | 1247 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431150 | 1248 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431153 | 1249 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431156 | 1250 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431159 | 1251 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431174 | 1252 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431177 | 1253 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431180 | 1254 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431183 | 1255 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431186 | 1256 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431189 | 1257 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431192 | 1258 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431195 | 1259 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431198 | 1260 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431201 | 1261 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431204 | 1262 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431207 | 1263 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431220 | 1264 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431223 | 1265 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431226 | 1266 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431229 | 1267 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431232 | 1268 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431235 | 1269 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431238 | 1270 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431241 | 1271 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431244 | 1272 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431247 | 1273 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431250 | 1274 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17
9431253 | 1275 | Torretta tipo T0-H unel+bipasso : EFX_I_TorrettaT0-17

# IfcElectricAppliance: Dati Torretta T0-1:EFX_I_TorrettaT0-1 (52)
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Nome famiglia: Dati Torretta T0-1; Tipologia: 01 - Bipasso Singola
Type - Dati identità - Commenti sul tipo: DATI; Label: GFCI; Nome del tipo: EFX_I_TorrettaT0-1; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.55 m
Type - Pset_ElectricApplianceTypeCommon - Reference: EFX_I_TorrettaT0-1
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_TorrettaT0-1
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati Torretta T0-1: EFX_I_TorrettaT0-1; Famiglia e tipo: Dati Torretta T0-1: EFX_I_TorrettaT0-1; ID tipo: Dati Torretta T0-1: EFX_I_TorrettaT0-1; Tipo: Dati Torretta T0-1: EFX_I_TorrettaT0-1
Dimensioni - Area: 0.0194455 m2; Distanza_simbolo: 0.5 m; Volume: 0.00013181 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Torretta tipo 2 bilaterale : EFX_I_TorrettaT0-1; Offset da host: 0 m
Name (Dati Torretta T0-1:EFX_I_TorrettaT0-1:...) | In | Contrassegno | Livello = Livello abaco | Quota altimetrica da livello (m)
8713964 | B01 - Piano Interrato ELETTRICO | 813 | Livello: B01 - Piano Interrato ELETTRICO | 0.724116
8714058 | B01 - Piano Interrato ELETTRICO | 814 | Livello: B01 - Piano Interrato ELETTRICO | 0.724116
8714070 | B01 - Piano Interrato ELETTRICO | 815 | Livello: B01 - Piano Interrato ELETTRICO | 0.724116
8714080 | B01 - Piano Interrato ELETTRICO | 816 | Livello: B01 - Piano Interrato ELETTRICO | 0.724116
8827430 | L00 - Piano Terra Piazza ELETTRICO | 847 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.107858
8827568 | L00 - Piano Terra Piazza ELETTRICO | 848 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.11142
8830145 | L00 - Piano Terra Piazza ELETTRICO | 854 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.108945
8830174 | L00 - Piano Terra Piazza ELETTRICO | 855 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.108713
8831387 | L00 - Piano Terra Piazza ELETTRICO | 864 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831399 | L00 - Piano Terra Piazza ELETTRICO | 865 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831552 | L00 - Piano Terra Piazza ELETTRICO | 874 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831556 | L00 - Piano Terra Piazza ELETTRICO | 875 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831572 | L00 - Piano Terra Piazza ELETTRICO | 876 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831576 | L00 - Piano Terra Piazza ELETTRICO | 877 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831590 | L00 - Piano Terra Piazza ELETTRICO | 878 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831594 | L00 - Piano Terra Piazza ELETTRICO | 879 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831612 | L00 - Piano Terra Piazza ELETTRICO | 880 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831616 | L00 - Piano Terra Piazza ELETTRICO | 881 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831630 | L00 - Piano Terra Piazza ELETTRICO | 882 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831634 | L00 - Piano Terra Piazza ELETTRICO | 883 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831648 | L00 - Piano Terra Piazza ELETTRICO | 884 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831652 | L00 - Piano Terra Piazza ELETTRICO | 885 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831669 | L00 - Piano Terra Piazza ELETTRICO | 886 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8831673 | L00 - Piano Terra Piazza ELETTRICO | 887 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.109402
8981761 | L00 - Piano Terra Piazza ELETTRICO | 917 | Livello: L01 - Piano Primo ELETTRICO | 0.023775
8981892 | L00 - Piano Terra Piazza ELETTRICO | 918 | Livello: L01 - Piano Primo ELETTRICO | 0.023775
8982592 | L00 - Piano Terra Piazza ELETTRICO | 919 | Livello: L01 - Piano Primo ELETTRICO | 0.023775
8982606 | L00 - Piano Terra Piazza ELETTRICO | 920 | Livello: L01 - Piano Primo ELETTRICO | 0.023775
8984271 | L00 - Piano Terra Piazza ELETTRICO | 923 | Livello: L01 - Piano Primo ELETTRICO | 0.0241844
8984416 | L00 - Piano Terra Piazza ELETTRICO | 924 | Livello: L01 - Piano Primo ELETTRICO | 0.0241844
9033323 | L00 - Piano Terra Piazza ELETTRICO | 1011 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033394 | L00 - Piano Terra Piazza ELETTRICO | 1012 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033406 | L00 - Piano Terra Piazza ELETTRICO | 1013 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033416 | L00 - Piano Terra Piazza ELETTRICO | 1014 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033426 | L00 - Piano Terra Piazza ELETTRICO | 1015 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033438 | L00 - Piano Terra Piazza ELETTRICO | 1016 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033450 | L00 - Piano Terra Piazza ELETTRICO | 1017 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033460 | L00 - Piano Terra Piazza ELETTRICO | 1018 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033472 | L00 - Piano Terra Piazza ELETTRICO | 1019 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033484 | L00 - Piano Terra Piazza ELETTRICO | 1020 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033494 | L00 - Piano Terra Piazza ELETTRICO | 1021 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033506 | L00 - Piano Terra Piazza ELETTRICO | 1022 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033520 | L00 - Piano Terra Piazza ELETTRICO | 1023 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9033536 | L00 - Piano Terra Piazza ELETTRICO | 1024 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9035977 | L00 - Piano Terra Piazza ELETTRICO | 1030 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9036076 | L00 - Piano Terra Piazza ELETTRICO | 1031 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0244
9041016 | L00 - Piano Terra Piazza ELETTRICO | 1086 | Livello: L01 - Piano Primo ELETTRICO | 0.0240875
9041397 | L00 - Piano Terra Piazza ELETTRICO | 1087 | Livello: L01 - Piano Primo ELETTRICO | 0.0239581
9413175 | L00 - Piano Terra Piazza ELETTRICO | 1206 | Livello: L01 - Piano Primo ELETTRICO | 0.0241906
9413229 | L00 - Piano Terra Piazza ELETTRICO | 1209 | Livello: L01 - Piano Primo ELETTRICO | 0.0241853
9892799 | L00 - Piano Terra Piazza ELETTRICO | 1284 | Livello: L01 - Piano Primo ELETTRICO | 0.0242442
9892801 | L00 - Piano Terra Piazza ELETTRICO | 1285 | Livello: L01 - Piano Primo ELETTRICO | 0.0241803

# IfcElectricAppliance: Dati doppia IP55:EFX_I_DatiDoppiaIp55 (3)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Nome famiglia: Dati doppia IP55; Tipologia: 01 - Bipasso Singola
Type - Dati identità - Commenti sul tipo: DATI; Label: GFCI; Nome del tipo: EFX_I_DatiDoppiaIp55; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.55 m
Type - Pset_ElectricApplianceTypeCommon - Reference: EFX_I_DatiDoppiaIp55
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_DatiDoppiaIp55
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati doppia IP55: EFX_I_DatiDoppiaIp55; Famiglia e tipo: Dati doppia IP55: EFX_I_DatiDoppiaIp55; ID tipo: Dati doppia IP55: EFX_I_DatiDoppiaIp55; Tipo: Dati doppia IP55: EFX_I_DatiDoppiaIp55
Dimensioni - Area: 0.0194455 m2; Distanza_simbolo: 0.5 m; Volume: 0.00013181 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m; Quota altimetrica da livello: 0.55 m
Name (Dati doppia IP55:EFX_I_DatiDoppiaIp55:...) | Contrassegno | Host
9804372 | 1286 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9813120 | 1288 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9813153 | 1289 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt

# IfcElectricAppliance: Dati:DDA_I_DaiSingolaIp55 (25)
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Tipologia: 04 - Presa RJ45 singola IP55; Nome famiglia: Dati
Type - Dati identità - Commenti sul tipo: DATI; Contrassegno tipo: PRESA QE; Label: GFCI; Nome del tipo: DDA_I_DaiSingolaIp55; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 04
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_DaiSingolaIp55
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_DaiSingolaIp55
Material: Dati, Presa, Plastica trasparente, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_DaiSingolaIp55; Famiglia e tipo: Dati: DDA_I_DaiSingolaIp55; ID tipo: Dati: DDA_I_DaiSingolaIp55; Tipo: Dati: DDA_I_DaiSingolaIp55
Dimensioni - Area: 0.0580919 m2; Volume: 0.000713903 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (Dati:DDA_I_DaiSingolaIp55:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Quota altimetrica da livello (m) | Host | Commenti
9764614 | B01 - Piano Interrato ELETTRICO | 1276 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9764877 | L02 - Piano Secondo ELETTRICO | 1277 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0.371735 | Collegamenti mancanti | UTA
9765059 | L04 - Piano Copertura ELETTRICO | 1278 | 0.5 | Livello: L04 - Piano Copertura ELETTRICO | 0.342273 | Collegamenti mancanti | UTA PT SX
9765109 | L04 - Piano Copertura ELETTRICO |  | 0.5 | Livello: L04 - Piano Copertura ELETTRICO | 0.458826 | Collegamenti mancanti | UTA P1 SX
9765216 | L04 - Piano Copertura ELETTRICO | 1280 | 0.5 | Livello: L04 - Piano Copertura ELETTRICO | 0.367858 | Collegamenti mancanti | UTA P1 DX
9765233 | L04 - Piano Copertura ELETTRICO | 1281 | 0.5 | Livello: L04 - Piano Copertura ELETTRICO | 0.355581 | Collegamenti mancanti | UTA PT DX
9765962 | L04 - Piano Copertura ELETTRICO | 1282 | 0.5 | Livello: L04 - Piano Copertura ELETTRICO | -2.89401 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt | GRUPPO FRIGO
9766016 | L04 - Piano Copertura ELETTRICO | 1283 | 0.5 | Livello: L04 - Piano Copertura ELETTRICO | -3.14949 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt | GRUPPO FRIGO
10477656 | B01 - Piano Interrato ELETTRICO | 1301 | 0.494193 | Livello: B01 - Piano Interrato ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10477690 | B01 - Piano Interrato ELETTRICO | 1302 | 0.529312 | Livello: B01 - Piano Interrato ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10477776 | B01 - Piano Interrato ELETTRICO | 1303 | 0.489567 | Livello: B01 - Piano Interrato ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10477788 | B01 - Piano Interrato ELETTRICO | 1304 | 0.511408 | Livello: B01 - Piano Interrato ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10477815 | B01 - Piano Interrato ELETTRICO | 1305 | 0.493949 | Livello: B01 - Piano Interrato ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10478628 | B01 - Piano Interrato ELETTRICO | 1306 | 0.506165 | Livello: B01 - Piano Interrato ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10478732 | B01 - Piano Interrato ELETTRICO | 1307 | 0.49061 | Livello: B01 - Piano Interrato ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10478852 | L00 - Piano Terra Piazza ELETTRICO | 1308 | 0.511282 | Livello: L00 - Piano Terra Piazza ELETTRICO | 1.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10479068 | L00 - Piano Terra Piazza ELETTRICO | 1309 | 0.508858 | Livello: L00 - Piano Terra Piazza ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10479386 | L00 - Piano Terra Piazza ELETTRICO | 1310 | 0.502366 | Livello: L00 - Piano Terra Piazza ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10479784 | L00 - Piano Terra Piazza ELETTRICO | 1311 | 0.506464 | Livello: L01 - Piano Primo ELETTRICO | 1.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10479922 | L00 - Piano Terra Piazza ELETTRICO | 1312 | 0.497749 | Livello: L01 - Piano Primo ELETTRICO | 1.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10480069 | L00 - Piano Terra Piazza ELETTRICO | 1313 | 0.525138 | Livello: L01 - Piano Primo ELETTRICO | 1.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10482674 | L02 - Piano Secondo ELETTRICO | 1314 | 0.527216 | Livello: L02 - Piano Secondo ELETTRICO | 1.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10482827 | L02 - Piano Secondo ELETTRICO | 1315 | 0.538899 | Livello: L02 - Piano Secondo ELETTRICO | 1.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10482857 | L02 - Piano Secondo ELETTRICO | 1316 | 0.520636 | Livello: L02 - Piano Secondo ELETTRICO | 1.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | PRESA QE
10667524 | L00 - Piano Terra Piazza ELETTRICO | 1299 | 0.508858 | Livello: L00 - Piano Terra Piazza ELETTRICO | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | PRESA QE

# IfcElectricAppliance: Dati:DDA_I_DaiSingolaIp55Soff (6)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Nome famiglia: Dati; Tipologia: 04 - Presa RJ45 singola IP55
Type - Dati identità - Commenti sul tipo: Telecamera; Label: GFCI; Nome del tipo: DDA_I_DaiSingolaIp55Soff; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 04
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_DaiSingolaIp55Soff
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_DaiSingolaIp55Soff
Material: Dati, Presa, Plastica trasparente, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_DaiSingolaIp55Soff; Famiglia e tipo: Dati: DDA_I_DaiSingolaIp55Soff; ID tipo: Dati: DDA_I_DaiSingolaIp55Soff; Tipo: Dati: DDA_I_DaiSingolaIp55Soff
Dimensioni - Area: 0.0580919 m2; Distanza_simbolo: 0.5 m; Volume: 0.000713903 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m
Name (Dati:DDA_I_DaiSingolaIp55Soff:...) | Contrassegno | Host | Quota altimetrica da livello (m)
9020716 | 989 | <non associato> | 2.6
9020782 | 990 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9020829 | 991 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9020856 | 993 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.99
9020955 | 995 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9242294 | 1205 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5

# IfcElectricAppliance: Dati:DDA_I_DatiDoppia (107)
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Tipologia: 01 - Bipasso Singola; Nome famiglia: Dati
Type - Dati identità - Commenti sul tipo: DATI; Label: GFCI; Nome del tipo: DDA_I_DatiDoppia; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.55 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_DatiDoppia
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_DatiDoppia
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_DatiDoppia; Famiglia e tipo: Dati: DDA_I_DatiDoppia; ID tipo: Dati: DDA_I_DatiDoppia; Tipo: Dati: DDA_I_DatiDoppia
Dimensioni - Area: 0.0194455 m2; Volume: 0.00013181 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Name (Dati:DDA_I_DatiDoppia:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
8780604 | L00 - Piano Terra Piazza ELETTRICO | 840 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.33
8780711 | L00 - Piano Terra Piazza ELETTRICO | 841 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.33
8781055 | L00 - Piano Terra Piazza ELETTRICO | 842 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.264
9025958 | B01 - Piano Interrato ELETTRICO | 996 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.7244
9026803 | L00 - Piano Terra Piazza ELETTRICO | 997 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9026820 | L00 - Piano Terra Piazza ELETTRICO | 998 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9027065 | L00 - Piano Terra Piazza ELETTRICO | 999 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9027509 | L00 - Piano Terra Piazza ELETTRICO | 1000 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9027992 | L00 - Piano Terra Piazza ELETTRICO | 1001 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9028918 | L00 - Piano Terra Piazza ELETTRICO | 1002 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9029349 | L00 - Piano Terra Piazza ELETTRICO | 1003 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.393
9029428 | L00 - Piano Terra Piazza ELETTRICO | 1004 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9029725 | L00 - Piano Terra Piazza ELETTRICO | 1005 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9030067 | L00 - Piano Terra Piazza ELETTRICO | 1006 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9030224 | L00 - Piano Terra Piazza ELETTRICO | 1007 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9032375 | L00 - Piano Terra Piazza ELETTRICO | 1008 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.0013729 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9032464 | L00 - Piano Terra Piazza ELETTRICO | 1009 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9032743 | L00 - Piano Terra Piazza ELETTRICO | 1010 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9033812 | L00 - Piano Terra Piazza ELETTRICO | 1026 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9034125 | L00 - Piano Terra Piazza ELETTRICO | 1027 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9034597 | L00 - Piano Terra Piazza ELETTRICO | 1029 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9036624 | L00 - Piano Terra Piazza ELETTRICO | 1035 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9036666 | L00 - Piano Terra Piazza ELETTRICO | 1036 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9037448 | L00 - Piano Terra Piazza ELETTRICO | 1039 | 0.780857 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9039307 | L00 - Piano Terra Piazza ELETTRICO | 1066 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9039404 | L00 - Piano Terra Piazza ELETTRICO | 1067 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9041473 | L00 - Piano Terra Piazza ELETTRICO | 1089 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9041678 | L00 - Piano Terra Piazza ELETTRICO | 1091 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9042515 | L00 - Piano Terra Piazza ELETTRICO | 1106 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9042532 | L00 - Piano Terra Piazza ELETTRICO | 1107 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9043232 | L00 - Piano Terra Piazza ELETTRICO | 1108 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9043284 | L00 - Piano Terra Piazza ELETTRICO | 1109 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9043485 | L00 - Piano Terra Piazza ELETTRICO | 1110 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9043767 | L00 - Piano Terra Piazza ELETTRICO | 1111 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9043972 | L00 - Piano Terra Piazza ELETTRICO | 1112 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9044143 | L00 - Piano Terra Piazza ELETTRICO | 1113 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9044365 | L00 - Piano Terra Piazza ELETTRICO | 1114 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9044481 | L00 - Piano Terra Piazza ELETTRICO | 1115 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9044723 | L00 - Piano Terra Piazza ELETTRICO | 1116 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9044931 | L00 - Piano Terra Piazza ELETTRICO | 1117 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9045151 | L00 - Piano Terra Piazza ELETTRICO | 1118 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9045418 | L00 - Piano Terra Piazza ELETTRICO | 1119 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9045463 | L00 - Piano Terra Piazza ELETTRICO | 1120 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9045635 | L00 - Piano Terra Piazza ELETTRICO | 1121 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.513
9045952 | L00 - Piano Terra Piazza ELETTRICO | 1122 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.513
9046140 | L00 - Piano Terra Piazza ELETTRICO | 1123 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9046401 | L00 - Piano Terra Piazza ELETTRICO | 1124 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9046552 | L00 - Piano Terra Piazza ELETTRICO | 1125 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9047528 | L00 - Piano Terra Piazza ELETTRICO | 1132 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9047560 | L00 - Piano Terra Piazza ELETTRICO | 1133 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9048364 | L02 - Piano Secondo ELETTRICO | 1147 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9048432 | L02 - Piano Secondo ELETTRICO | 1148 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9048449 | L02 - Piano Secondo ELETTRICO | 1149 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9048563 | L02 - Piano Secondo ELETTRICO | 1150 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9048807 | L02 - Piano Secondo ELETTRICO | 1151 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9048961 | L02 - Piano Secondo ELETTRICO | 1152 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9049497 | L02 - Piano Secondo ELETTRICO | 1153 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9049912 | L02 - Piano Secondo ELETTRICO | 1154 | 0.77 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9050194 | L02 - Piano Secondo ELETTRICO | 1155 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9050421 | L02 - Piano Secondo ELETTRICO | 1156 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9050584 | L02 - Piano Secondo ELETTRICO | 1157 | 0.423242 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9050794 | L02 - Piano Secondo ELETTRICO | 1158 | 1.0995 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9051027 | L02 - Piano Secondo ELETTRICO | 1159 | 1.189 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9051364 | L02 - Piano Secondo ELETTRICO | 1160 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9051556 | L02 - Piano Secondo ELETTRICO | 1161 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9052663 | L02 - Piano Secondo ELETTRICO | 1162 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9052675 | L02 - Piano Secondo ELETTRICO | 1163 | 0.909763 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9052907 | L02 - Piano Secondo ELETTRICO | 1164 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9053314 | L02 - Piano Secondo ELETTRICO | 1165 | 0.905821 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9053478 | L02 - Piano Secondo ELETTRICO | 1166 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9053803 | L02 - Piano Secondo ELETTRICO | 1167 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9054664 | L02 - Piano Secondo ELETTRICO | 1168 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9054722 | L02 - Piano Secondo ELETTRICO | 1169 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9055022 | L02 - Piano Secondo ELETTRICO | 1170 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9055241 | L02 - Piano Secondo ELETTRICO | 1171 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9055406 | L02 - Piano Secondo ELETTRICO | 1172 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9055521 | L02 - Piano Secondo ELETTRICO | 1173 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9055759 | L02 - Piano Secondo ELETTRICO | 1174 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9056167 | L02 - Piano Secondo ELETTRICO | 1175 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9056401 | L02 - Piano Secondo ELETTRICO | 1176 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
