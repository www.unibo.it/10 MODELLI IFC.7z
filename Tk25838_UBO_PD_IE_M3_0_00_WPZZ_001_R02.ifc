Properties of the parts of a building model (IFC4), part 20 of 23

# IfcLightFixture: LFX_I_IguzziniModQf61.01:LFX_I_IguzziniModQf61.01 (177)
Type - Costruzione - CFG_: ---_0001; Mounting Place: Ceiling; Mounting Type: Recessed
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: QF61 : Round fixed luminaire designed to use LED lamps with C.o.B. technology. Version with rim for surface-mounting. Reflector vacuum-metallised with aluminium vapours with an anti-scratch protective layer. Dissipater made of painted grey die-cast aluminium. Product complete with LED lamp in neutral white colour tone (4000K). General lighting beam. QF61.001 - Ø 153 mm - neutral white - DALI - 22W 3300lm - 4000K - White B02S - Lamp LED Neutral White CRI>80; Modello: QF61-01; Nome del tipo: LFX_I_IguzziniModQf61.01; Product group: recessed luminaire; Product Name: Easy general lighting; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___qf61-01/
Type - Dimensioni - Height: 0 m; Length: 0.163 m; Weight: 0 kg; Width: 0 m
Type - Elettrico - Commenti sul wattaggio: 1; Lampada: 1 x LED; Number of Poles: 1; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 24.5 W; Voltage: 0 V
Type - Elettrico - Carichi - Carico apparente: 24.5 W; Power Factor: 1
Type - Elettrico - Illuminazione - Luminous efficacy: 114.49 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 69 92 98 100 85; Color Rendering: 80; Color Temperature: 4000K; Lamp count: 1; Lamp Light Flux: 3300 lm; Lifetime: 100000 h; Socket: socket; System Light Flux: 2805 lm
Type - Generale - OnlyDefault: yes; ApiVersion: 132383237; ConversionDate: 11/12/2021 2:06:31 AM; ConverterVersion: 2020.2.4.0; ModVariant: no; ProductGroupID: 4; RlxChecksum: dc0ee0ded7ee9f74aab62d78479c3844; RlxData: ZN3q8ryccAAPvM7nA/UMAAAAAAAAkAAAAAAAAACmHMHcAf7Yb7fCEQFjjkd4QJ1aKHI7SNmcp4KwZ490Pv34eIl5cEOYe2AnNqvn44aBFLpRckhfaX4ydCtF59Dz+TWkwU4qjqfyiaZX2/YXfCJfyAg78ydKDJIVkAfWww9QwZIscYj/dVH4fRDlew4dH13bg6nABY+N6Aqu/uf9U/xqtI5cSk6hJpmGDv282b/tGOkeqXtaBaX0pazC85oRFiWLQ/Deb8FyxakbHPV2LjM2jPbOrryi5X7HgfB/mMpcIjnY/C3AU5z3IrlYN7eZ39wKczYP6kuZipgCR1ZdY257Agl7RI//YFt6jLLjct7xdYx5A/nboK3RrgNJ9t5UbJbnQMhNJ7GnuFaqa0MpCT0VIr28VVzRkdM5H2Ll843/uebq95upkVFZGt26l/cDeLDUCaiR6yOWuWSYJFzqLjgzfvAk4DNyZjZcfKFAOJBQEdIJJOHWU8yok11JWZ6U4iK/ORFTK2al17fxlrBoCoQVBnvIiiU4pT91l5+h658rUSZPB4H4v9PW5yLo4SzQuCkjZxDvTtH4zmiw7tIjrRIsoxx7sxlKk1E5RA0c8VUR58yjea7QQdn5wzcgzYuhTREZX1T65Dtvn0BZjfhDDa9Ad2R5xAOiARBegIFdZXi4eEsw7WtNpQAh6XJB+d/KrWHycc7ALYZh95FXMJa5Y4NM1MUc69Dbly5gRBdwxJKjLjRgZYJiAsQi6WKtdRqtA55V8hk3U3AUg5+aeorpXZlBbDwpIhwIoJWBXDANmT+KnCZQMnvfT2Y38bDlZA5IBG4cHfK4uxHECBYZ4MmLx05r7h1GJnMTBo2kNPMxnMY2Te1Zvz7vmI2Ukbu/knxZccmQxDSefszbVU5pVbl3MJr7czCJn4yedURVg5EJGITSKuInbq8aX41RFd7h/XfmS2ZvUU2HxYzGay0Tjz6h6ubF5oei3O89pIscQ+PpstIzu6i/G1zbv8hrQb0dFv2IKLMbVgu7kL69tKHDvgVMLZ+NVk/t/JXBsmoN7QdSu3lboLJclZ0ZtOHRNARNoUVNB04SDBe1QxbXWV3DUsHuDm8C9r3PxfKBufrvvJch2dMUdx+T+Cg2Ob+Goea5bUWjMN6HSeD8zte7wlApM5zsHmJ0kLcVzcrymjzHPqFoB+OSQTMiK9Hx9T+U3gyuTYPt9IXFZLOnqG9dSJstYvH8dArFywKKylN9UTO+DWQOT+chqQgPrwpiybDPGTBy5F0AidqnrCQJl2w/0y766QN8Zq5rXOMSQw4k49KzB3hIjDnYCSHaKkt9Nu8mQt8DQttBLQJPHc7y7rNHKbaVF9KHT/3hZTnZrb4ISk0k1UIaTrn1IwPoS4RwKKsy8IriaRjZCrNQAWulDDU53/vsCW+5sOLqUEcSplXf5ij2bSwO1zl7EhWR2uFE/hUaD29baFyWSXDgxE4ZZ+KHQXwYHMXXMHeQiSVJvyRIkbLIdqCtTY4jKNBNG4QAfAoGcM3KoEGWiIiNKxrNs0rTddZ8NlXhidtBApOSdx5GxM0DzeKAlPdqRc6yAbCwqD2nax3RGvOo2kFJjUUmISoK0bL0c/snQfHF5d8ASR9O9bBsnjwC1XbH/SuKGExj7PT2e0HgzNNNmGvyCKQrovoXlxs2ZqsvP1b+NWDPAydFzZy7I98C7oWCYCu+Ok+UUL+TZ12Jn3xoVn3Sc0/TV8HPJFk3k++9BF1xQlq67SuNw6Jdkouep9367cb3otRy2bfLRJJfGC5U+B4tSN3j2cB1E+wCV6/B4CtNI3lN2iFni2NWo6gtp4qKMOuuvwj2CPSTSCXsXUILV8Sp13LT5JaU7BLwZEvx3/SlRsuI+d1jq58YRQTKBfvVNXmIr+SBTwGUzmNWfTbQ0ots38DTGdllaf9h3IJFvSLQc9QF+1RsCL5YrTAPz8UUc4yF5Az+/wLE2pzSCPsEOFfGDAIrzZVuvTR81FMmUKaeMA5NxGTyR1NnPzU5uhLJ3M7JlqgX+ove0zPkOQPXSVGPt8RVG5Vho5EFygSbza+rrNLEoT/0JP8krDw3djphhvAiXbxmI2r60Zh+fAXhtElekm3HJF+lOj2LJu5QJItvlhQnt7+V4830HrNcXECayyjQUvvKprimZcoYp2siUUwqTC73zqqUxc7yo6+umjhvAIWZHqKij6Iai33H6M1+TA3dtKj/JR7Sfd7HUoK/WnNt2FUEpa6LWirOIbpka2+5b/jkIYSFug2MQCnYobRLnhdl3t+FZeSMD5mU0/9U0XzlbxtNFG2TCVE9wDWLHPwiGLCXLspGgOA7P1vMiXw3jJnw6Q/BSvforD4uFcAKXC0Fym4gjJncDQcp3BuI11f1jBKqHmcH4VpdcW5fzJELbYb1Mrycf/Ujd5ngxHvD0UgbL8E9cQim0A7s3QZVCFjcxXENIZMWC8fgwPSpSnFS/v2rGuL+xsgF2aKrfVwkGm6+uit2SuMRZ5Tw89MN6DAM1vWRIINv2IlO6HsuCUjWaw/x4VCCYW4gXcLw9LdfJpoytn9n05hb9st/Gq15zLQpwZ4215oGTroqJsK4u6B7ztDxeg5TPaUs35JrMrWdniapYZHKperOV1uy5v5Vkl8m4FfOS+1fMVwH7jQYunMEt1ImetEROFi5bQAagBgF72JDz84yP6DJN3F+PYDu8h9U9gMoONfko68J0ya8gVpkXQQ8b7PnwjuJyoObwtoaB5Uybd2Q8XH5CVn68jzHSz0FF+oIhcd3R2fgn6ujFJ1eM4RDmzdk/Csu7QG/vJEznNrRYYozcxsbRsst3GL7nLMHU4XkpcE3YVb/488Ch4pJGhd9wnxO0HXx9A61dPuY7DsLD7S2X1JMU0CJ6a9Agj+QnQy/fX+xXUGsTgT1sWp6DzQh/kM2sTBMVNWDqI7aKFEHRWHGZUJF7l6qg2B19r2TuKxVrVyFvASVyLeL7q4XJf2EYWjgcV8e7fP3IYcLjFl4FXodbn0N7s6LT3VAdD029TiZbulSejpbmZL6jkuOXC9ADDqxZuXvpBzAe4LFKET5+dALOYso6cKQCCWR2nJnPqd1TEfKRpXT9hAyBk4PTVau43uCMOazZZz415+irXPX6bhUQ+JM/OrL7tA7QJMHcGZar+y+GGdr+tRd5UJ4/utg5AbVcqHzzAyZHqJPKcGUU76FX/W7iod29aaT9O/GzpHO+pfC/e6DYMXXt5DwjDY1oDEnP+db/PtdOGmg5mtEm/onW4HV4CHiS++LVkWdC7IlPXW0duoXil/huHVB3GpoEuEj9J6xWB5hh8ziyp0MG1lQLXwEizIVxsC7JM48tNDlGdr9BkYuRvArPTQLggptNnDTgtVbjAtgcUKxpg/XQCGRDmxSusdOAaXNmErZKcIfMqUbn2ClpFP/u83/h9Fdoic1fhneC8WA5WHb2R11qt87imuTbMJy02aKbivbR0BB8OgO06iL+HRCGS3VrPyeeC+Uw2Jt8bYSX2FpivVkcFZBazwF1T+uW/5S85H7Fu0orDoHi/iHiFhinO32FRWOjY5c2wV/gJAVSt16NFPGZ/0uioU+BxQ30hMX4wEUTEdxX8Sb7/NNVvZ43Xi5FB4BAMep1GE4QUMktgF25X9cXFr4MfjL2HL9vIKtFsWaGofI1YZC4MSzYXc7jD5SNSdsAu1lVy/OmRtuUD6hofs0Ap5EL7MKs8PDwmUTYkI37mumdafwrsezWQZP+K+7AyKpfezHcVgQKmAaV/UYinXqKIJtB3yKjlEBmIIvQ2znczt1YzxPHZHyVlTmYFkNscLj+RaBMGwnPXJVHu0wvAtTUKzLa1q6DPf9sspMoh5t1BvCIUDn8ktal+bSbKTR471iXOKpbZbAd8PLSX8ytpoL54Qc6/OlQPZ0XqiBkS8m/y7RoK0vtMdfb0CmHuMCMeADMSnqYsh29BvWT5cDse84oJxMSbVKc1WSeC44TdLZxmRhcnHf7NQx7BYjsTaKMO455ZL9Cjgz8Nk/vWB6hDcC3gDiO50CCpdaAuC/1+MCSNnaKQwZoroxM56DQ1Rn7KfXocvDfBJuhru4GnV8EME49O3qKT8KJr+tBwpo8iW/VLOkKH8LATLxmPb6kx59d6FHDOgZZcckDgUIiz08PyJeup2oI95LZKk/rSHRkqDawg818AkIGoT0fGK4CorDkZeG/SYaCEUT9b/Ix20AB9/jnb4bduzA+BhiZDkjX1N+YJj4eN1FMpYOI0gH42a8bXdAVkHHlPwPjPfATSJYRwx39Jv/fILTRNtspbomIrKhmz/WholAWAOgwMc5d4NeWUPcXsOyhuxGM0dng9ba2v/4C30LuhcZO9TLHcqNjeYtMRResCinqtsG0KFBz1Ho0S0juV5KIn3MLOHNDZukIzT3WTlVznx2Ybd1SPrpjYlEQWEct14E1XbtoYXKOUafeeu76qxFe94U0r+P0W+E5kyJAq3lq3OvpEc/qhUHSPCS8IPXJYUWk2UPa0ri3jazxt5WYAGZ47LWY7upvJP2cafr/R//DQJB/+jruOsdFCK6q/IrpAq0k7xt065YuEqQv6zJxOPu5aCNTuscHgyJlHbmRd9/tm3pMguZlh8oc9Wp14cmwnaPcS1LLsa9ycOJbFvQ5cwpvaUmwiCAQ73OGxXZpiVTEhrZdCywTQqa57/cOIzdwqC/AqsCcuqj2wsEqzDUuP5rylulnfi2kvpY8E/i702Ywfh4cq+N2qBGgBsAoGs2PGRsXjnF0XTbWilZYEB/0SOi41l9tn3yJGq9kOLy6ydT5zEEjOQwSxOVvBjSykG4TZ7kVk8mChKeaYkefDv130JX0BM8r3Wkp99pOS53ujnMHPmhhXiMnHBI6OrnQD4ovWli2+fIfDECugbW80Wh1uzZbVW3nz0rNOxZsRJ70MExCyomWxSwiksTpsaA+VRZ5fUAztI0NjFwjWhC8EBcQf1/qV657XrlIkMq67f/18kNWwqb2Qsl5lQTB2kUWCUWzAHYi0YtG5jRoAW8l4M+2zz9oLRk7XNX1xn/QO0FB0tKL34JEQ3CjRvhRy0r+yszStNpz476MM37q9uVdhCc2RL5pWBqB1K6OHIJPVrCQH8mdhFTfgz9urIgQS+ROgjzbbxrLPLHB1+WOAGgySQdpKNwq8zAgFQ7zhudOPdKOmqvGr7WxaYfbU7wcEI0w7j8KQX4j8Bw8gnTvhrgN7XqPeSw7P1KItweEGCx1yGvjLmPlq3qYzKx9QboY0kyjDiAKHLD+bU5w6H+dOwTXmc0WHrfU2y+gWcTkEuj3LUeXoUoOShKTDdDS0KFzOHEA9ShmXRyBxSPm4a3R32rvt9DCOCcHq3W5ZH4kMj0pfpm0297+Y+B74CACUsWcZJL3Oox4zyX3DZ8EI1RJ+9ake/PdGujsMZ2NLank6qPGJ2rihiTnGdFqdm9hny21ShqIzf7LLUt6KeikeXKlCBhclUav47HZ0woegigSPXoU5LV8a9NM1o+4O9XGpXGvFZN3VNNWg6VI2VXiT5deRgH+BhXyWzH+ObSm4aBTDlZnCoa48B3FajPXjft3G8jb6F8PSRog2TU6lhI434Qq1sDwN3SWxHLbZZ5K9FEHpB+5XvDL+X8yLXYFzMYEVcPNd9l0a3Elq2Bkf0p4udo219sIOfJtatn7IckpDqo3C3DXq4G3AOJN35KW86aMspzZ96CuQgDGqfVFJk7dcBG9jU6Viq1I1QBRoZ/AgRuSVhVVXxbfVRfezsrvEQbmNPfG6r/GVnNN7r9AvLj4sR8sC6ByJRFxGihsHOVYExFSXuWH5CiQiGmCQg3RLmz8bMDvJvWbtsosfi63D2j8eYpLDVIYd8678ghso17VWWM8eLYPxgwK9aODLLB+jqtoregG34M9V5MHFYIdRXCsPZGwLoNXquOT8s1T/T9K83KxEF2A1IyamBRgT6HSLXKPrXYGVwNf2n873LGRoLP6tyQ2GhLHI5WiJbBqTiazkWpSxZTG3MMT6QMrfDi//s6QsCabyXL3WfZkSvQkdDORcPN8jnC9ADVLHb0B1U972dgDlD8Wm4rOFdKuS/SrdPKijOMBjNDvdyIjvgxor0SLTvfNbKK7pmTF49P7YSj5P1A7xTbvzx8s9lGEorut/O60EWzS8WOnRK+FOHw/HmxsI6R8qU+EFlPYrNegQf3nkLnYm3Wm1nXq69zwi+wuSQAo5rytQKh/TXhw3azsxLtLXoGQv43rZ2JajIfhchVwAJ8ATrh4P/Q+b8OmGB2xv6UeNQRRgLzCIBPTHz3/9DIHhckxupaDzbN53/NqBhLin+twR0kzmCUpqaHSH0aL0/I/o0MwLhOi3W/0NkthdicVnqJZijGZfDJ371TigqGolzXPD2SU14ZS8NS/v2nAS3i5hSsg94oyx/va6epcABOZnYQm5KPIe2PWY7juCA4k2ztMi63GsSDzwP99nRERilPuJAMqVkprJzl1itQQmwNP4OZ/bmVZpYw28iPv/EiyWpQ6hYJtrtFYV+Z6KAo4ii77/bhvprxYqQCIUPlD4fbDw/JuiyuML969hs0fYT7LSPuozaqTGL8ogdYjvXLS4E2MvdqTZ3+yzFvZW/gES/mL1t8eMkr5SSWk0mqPAbJJ0tbq6oQQXVgcPcQWQzXdLuL1C9hxNYRcg+l6woqXN6SuLaf+a5wReuV+fHkO1TELdMhyTQwYSzzKPy9zYcoPTSi2Q2pOkN/SOGSN2T3XDWLA9UkMLR+OW/BhJ30a4i0ANRA31/yQFVwIluo7YWjDbtbIt3qy+JDvHRUesD3LFuTbFKb82129ljkKz7hS8ja2A6ATdqlY2YL/cXS1NzbVmDE4kG5085amS9Xyh2MJEAUSanNekmKk3im2i1vCP4O94sW7V3RqG1qyqEltKjj04f1QYTlvOSz3K3ZINZ6yEVdevfx4QSi9te0OgC8bgDXAlcMD01nytvkeuq/TRe7OjZsC5oP2szo5sjrfsZUYp5hizRt/7D8eIUESRe//f2u27rWZOHmXTQ8ctER3NSla/EkNgC17W6JHlCFNZu2cUqSJ2CfJX1OCxXUz9edwSrXFyeK5m54mty02cWLO2lc0XUjGqNcq1Q7/Bo9gvS6Cp0iQ/e/j8j+w5bTTtenWzu1Vi4f4BmxpTLi1FMJC1vnx6RUSXeJwg/pEzAgHQofijwkoOqbE8ZQ9MzmIInrWnFznNGick40SAyKn/jCak48IajH30Pt0d22tHkIGZmAAPxdxYDZRs1bPcqLyq9fyeOlZz08/qgLkheVCin+LF01djHs08xuawvhxDeI1elO/aJ27eH0BWE7Fm5+aOhsAOGBpwFLkEe+3z03SLOEoraU6pofVd0mI+Od6aQmPEzpACnzXcci1gXnTeO9Q7yCY3ltN2At96roH0qZL6vyQcQTDDEBsPlKRzRK1DmR1++sV6mGmXyXTTu4W46zp2vTWLIp2AI9ZdmQBlV03OcQI4N80L3mC9RwHOEhXma8dyNrnUQenxoNYF+Nv6l5+FVur1dsK8zGSYYI74uwWZvxs8kmeD1ztEz7Wq1w6TTsh9YWRnYL/Me0+TYv06Akf1ZzvywOVg0CywNYuXGWzc+PJp6tpQa4M3lY2PL+IHW+U3FO9RCZr6R4VRKiOO8FJebr76MnKhiG1hnOTzvk8IaqYaaLYWjYvvY3ox0njU/XU7s4mfzgPzJfWxS6hVvWGE7Icqj25CVryP4FKjbaCN9kDvJH/gZ3F/6NYT75G7KdfVyNXV2LQEYrvYECX6GI/lwnl5fVrmhHvVaaTKFI06JketTInGREiuLwokJm4rNLwm3oEOyxj6ui9FlDNvc1sTn+BB8DwfHsEWJrUrx3LFgkuz36/0ZMa9YQ+OjOAVUtD6jv/8Pa9lZDicWkAcH9R/6+Bu8qFsOk9mjnEwE8VSb2UTJYTllqYQM5TyV+DpLJSW9udTlHLmGz6MSaDLC4QTCSxeNO3c3FlVyhx7BrF3qGJrYtW1pjIAmmV/CVmvQNfsVI2unNSivzcwfNIAG8oKTHFKPilDCE0ca2zxSDq/HpC814m7dCGQVFQE89gT/kV2eojTJqc3WBuUWKHT39lygdp7SWwjhRpmOVNnAL99AfbTeuwkQf6HMQkZos8aOz6NWA/CJoyWkLcXzK7gPRw8Xiuiy7eME+nHz2KWMR3mBum3MVuD2LXfPHRC2L03j+PVoceBSiUKoP/0QA6xnM+I9z5sHd8Cj8sZpF2RO9rU6xOCQDkgsgwlG806KHIbe1Tr9ui8GIqaOcvTqtUA9+EZMI+h84ZVqYujaySaVDIDRbCIku5pcWsJKot+9CFzMvfronpP1E9v5NNKEwC0oVjgDqhh3pFXzkBAndtHx4ALn4vd/RT+8tfNG5dCslTORXbxzcO4lFaowh71Y1sYdk55P8PR6FSDbIVoYHfobh++enmtkh57bFiNSRhJNyASDbD0L3pfsNmfioDbD25Ap7RrRiRBvbBux8sQlwYDVoexAxAKlMvBFTkrAAr44HWrMGUNhDmqNRVhQQZVsffrGkmk70bqbf/BoO1mipXrrnX0BEesy7bWFgaMZUW5E8mVyazoKhlxDrRkghWOHJ6eVcrJJXioYzvMk9zeQWHxlfso/ynpjTeRNLzJ/0tienoH5NZvdO9z2y0ANx5936woAW512FIS2psrxf8gb5Aha8zIyQK/vf2riqgRNvpSmONjOCOiC44r62KVdREKWB/ZoNPT5y8uttRhm+XRulhIjYOier0tYaRoz4eJpZWaIE7Gen1AK+MeUOATBuS8KL2V8TJPOY10mP/+6yeyhLNSG6pbHr/9Ro6cdICCdAO4cGStBSNR1I51l3k7NCe627XASbNAdc5p3zR4CEsGv9bqJSFaCMXoBbx8Im0aWYI0dKyqG96Dq4Zjm0gfnzHkN7P8jint0yZZcY13iytrMKsD8tEuN2/VHgAXvsUTB3InIgyI7phRm2sgI3xauBohPEJfRHymJSvLnX7AKxroZF0mJggSonTGFq0yFXFYGoV0jdASL/Ftegl05vBSKEMDSMl21uhMx5M4owcAwrYwhXmjYKRWy+kVKAW+uCcp9OVjdQj+ZG/HSEFfXq8vl5fG2i27YPCa8TlvtRSKWoVtlchr3/5BLvZ2QHXyIg0G9GGhqVxCQX8UNYfO06Gm0sLFKk0ei1ksA6KUF8cjcjCWA2PyKa9h+1CIwbVbJu44WrAHuNSnS43S1jhhvagpZDJWS2gD4g3XAx/XXB7w8WtCyi424/c86UpqIhG4TWzR6CFcjcAu4DjnMxzTBeT49CUsXWOhhOkQYCxu0OzUXoSVMxsgSmNnCO+Rb4adtEtzHp1xrN90GDINvn6J201lzGrgmUy5TczQQJOy8ZfKNvYZbs6SSiikWmTYSHokpsryDM6vn0FjmY2ioEZp3Gy25bd7ARfKmfsZKYNymFZBTHDyrsrhwaZ6hQoRxnEWqlRIyHFehVe26w21QFViW3nbvcvHCymiwxWvLOFzogOtLYe8QK/k7ownFHfIXNQ8s0mW4VsHrNK0uulk8QRNMYJc9AlN0aM9eDxXsUXRoElBpCL9sQ/fLbFZRKLM09w0UXOfGrltSXsoE1omMGLK4iDD6vI1E+wbgbsKhkurQN78GqCDgTbAsIRhX7sjkNQUhODgtmRAcHXmKgL/KVcbyvLiy/VeE7gUOB/V/nLH7NGq7FQ/aUFV6fCHDZdXIFM7wYuiosVyL1YbJ4+4GbDwwkRbBi2JgiNHcyc1WeccXawOB3udPG/WECv8m8a4FhIPFsN/61LyusFShd7kMqcV5tOcu2ho/ZY6SnTAjaoAZ9jUF9cczUVhhfhA2KVuZ8pSimCxXYmDfixAAEYTdhnjS0ccEhI68sWRPC7h7oRG2ZJrWtLgWRjS2PzaYnS69lOT6sI+lhSg3ci4vC5+MRDYDi/Fi4nUVGbpp/W972DaTpq4VWn1g58NAKfgo4y568U5WEh9cjR0K43LymllpthEB5g9Roij81yBsFjAuTNZi2jZxCcBlCXgSGSbebMmqhmAZ99KTnbVG7IP0N+x+xASqIN0xXUKyYbTisRMqMlJvulKYUJxoFOXoGmVcprZpJec0I4bDD2SVltu5zkwln6i/XO7lDRD2kDt77HBm5pY4fcs+eRIz/RnTIUUc/uoMTbUvisGESidKkpgQfY4BOqXmYVwwP1a/6wVy9xtmwJ4P4+BOlMkal0D3ZxC4E5oLUHpYmXFBhpiUfLc5KAGrdcMntESheyIRcFrQAwmuY9mjceVasssmuYzYUBKArZhcCV/MSDwSnczgJRLxHcWdu+9+SaXn+CLl2ACmcuaedfB6uR8jBJ3udtfBAjTm8f0NrbcRCtYfFnoWb1l2v3E7H9f7rCZHe1nEQJOFUPdiyXnKxcgz46HBYqKff03CHNOVO/whfLV0ulk0xeh+/dnuDOqJBuC0f6RkqUQQnoeBMZfU8LrsqCzSv4zeuE9Wd7s0LQno5EXN8NiLH0m00sklrzukO4a9We361XzS2PfIG2tLvHD3gEUPrOteM8f2+bgPk9XYVc71DfpLYVrSoqrrRIA9hCN3ssEYFt3AGkzAjE/F1wO9YTKarqS4gY74bPK1P7IIoCQ1JTv0woENKreU5TFvkYO0ERkFk9VgzAABioIXHaACZJWjPWP/yoIWM9gWKrnq0LVlBNm9+pT1JRx/w03hqgKNXZPaK2ExOcH4cGbNYOEmjnd236Nbp/h9Om426gEUERDUo1vsQORDJufdr1ZK+iAJ21lYYBEmNQ22BUSOHXPL7gdanMHxwfbbTkdkiDUpz1AvpPbdUzMQRDuCL+rdb7kTKBo45KxsAlk4cBWfV5r7bB+jT+ryGMmw7vevUd6us1vgyj2mnvSTUee4yDSD6SIQHXbwkqgen3nQaq3S6rrZO2F0sjKWjWdUq3Y5ulf6HWgy1b1iWGXea1Mg1CX0d41dD7PhQjtzj2pH3BpbWNHz1JlpV71isaZyH2ScTPJpFz9hTKc97GFw2nJk5JhpfFWr60ySVwC2RS4kYO9mz+eTLYYjhO9aHVE6oMYekOIxPmgHooRfvYMjC3UcqTMkxuHuHtvBiJT9xw9ddT/R7SKKf4x31c4hR1siE966jZVA2wCYU/1ywH+V2KBSusSO/iFdO5EM/p/6eGj5umvkRL5Wpt24F5xLjjcvxCHldKbQDwLgLFC3HQlM/JZjQdb3bwCZcWzu3xTmJVhHALS77ufib5eQgEmyuxfeORR2nrdo3Xg8LwFLl/ECwGgTAB+xI/hNicBLdqPCDWumth5dhypkA1ZWGcstnFXw9/hHad/INNV8nzlXV6uENtNqr9+jQz+o7l3g9Scgk8Fv8yKHuysDT/JYxMRPJLiQ9EUMIT0jU8KN8NPTCDTxHSz/NgDShcCVdIz/TPD6UfwFiToiT0drrtY5lDUbo/uyK+eJwVP4xS3TghPos40pBj//wqgwgJhnjhJx/NFd+1oisAGH1fQaeTsROFZ7V774egWHlQ2HJEYwbHNOWCntcWT6blV7NFddy2zg5IzvjKkVo7fLrUjIbH/pz7CPEfU9NTHRXUX5L2OhQLcWow2srUObdyAPTHM+inKbYyNGl3U2y4F1XJFd6CNSUEHbc9WNxvGvyVdFAnbWaNvQ1Kei7fUa0JuYybRyDnxYhEcQGtyPxhOVx+h5Khor0U8qxgGGxXKfjIyoLyzqw/sOrvIwPzhHwoz6x445ZAInpf7MfBTrAr2CxwtNxHuG7WDnHOSF0g2ddn0W9x4piwcQltwldmiE1qlcM1O5GLQSbbWYnBeNTCPE343B6iSbD5DQYyVUxgUZ9HUZKcqWGovDq9SdFhsvs1Pge790nnZW3psPa+EZGOtkt8ufDB1ndIy0rAkVoll/yliz3k0r65Cd/IFednJIDMtzTeN4aQK8nYjdHqIhPNr5aT/425QbkI/bSnTOc76Wgg5jbRfG1bloRPYuNxPKfkdWJEuBPqU2j0j0ABQKZ5eWk0a8t1jmn3btRJk2+3D0jjZQ+OSqFedRjiycs/g22RLdXsfT6lraXqU7DRA1MrTdoRkFyeZW8kR4sXDP4Gv7TFCxmLqp/BHJzsnh4L8yIYdPRKVAF7okpEpd7PISVCwyqwT3J9g97DiNSU22jLi30GNa6XsL0X7FmGQNW99bjnDKPuM2rFbJMxNd/xnt6IrIgpuJEukUNA/WcfTDH6Xid42FKGjBlDkv3J3w0NSuJEgBUx51cw4zVyDWWlaXabeiJt8sg571HWIZcToGqThHXGnmgKxohR756ieT3u1TwZzr6dxsumWTZnOpq4WOcgoc7WsTXeeYr9hTySTknkgOVNMGFPkVY9xMg++FSQgORoKR6DpNeWKeMajY25BiGsMYuKXQgNsvWrMSheeDuEU6cYOkgrwz5/azUfKxD06dpeVCiB5W9s2ExyWLtIlRuEJ3nAFF4a87ufycR+cU5N/8rs1ey2aKj4Aaj7jIzQfb6cZz7Dp2iIydYmK6N0+djuWzHGLHCSmOKu+ICH92Tp5gZn2vymxj9GBuwhm0/ld5GzpdJbIzKxON8aElKLauFWxbw1npqzhBOXPBJcMvBcKzIeMHO+fAh37LKi2wEC7TwForYDlc3dJsSq36Umdmiwlbp7Njv6lBp/GtgbcBdnEwW1OHLYezV9sX9LoTDSEFACEUZsg2ltQnnu2ODcNWTmMr0kLLgCKO3kydJTlt8PkbRAz+aRkjQ3QpGcE0Chn/N8lSwWZ0bwh0l6L8IyLBwjDKdTu2qQwuRO7FozhunjceEC10e4/qRFtwJBkwceaTgIpKhtqcR9czPCXOveo1/2fhxI6eN45wghk7l05Bks4bRiNNJhPKKOPlYxTsmgQ0ZkQfYC0HAdQfZfYV4QZhg+dse5IpGLA7AotC0WBvH5o0MR4TVaK+SXT5d+2iSx6qRUSR1lg/bEZkt6kGfy15ocwxRh0dXd7cF4kaVjnXGcSOc0Emd4wu2ij1Xz7mgUqH5TYdNQxmmqLJT8ueiBdXfaE65ztpInjT4Wthzl+UgzykQTktqxSCVVV5goQy56+Ob1eTXYZYUIWB/SpkuqGYEQtnlYk3j1y8v+E8Ue1kmJb9TEc+xWj9a+8n3CoDD+zrVsdoBJ9146enV/Pyw9OSvkWPFr8D46fLKGr9r/7IeYXAolnbZEOpY0d+Sb0nQZm9FnwnLn0a/G0Af2MguCW8VNsPwAyQCpXdSxPhopZpILLjSTC7YRrQHsDEKl8ISqyd7IS9QWp7N5+hUZvOwX1VBXjiy71lJYNSvlIcAQ0Krhotctwjz5VUCt29xJXK30ml81R5v9XMMzW3MQc9ccw2o86vsb9QI8Vglc8SxFc7Z/l0PM2kQKavp1PbiYF4H4NbV+y1LObIyRmbTelVwju2sBsmdTTZCiR5InV7DgLduamb0jMPnZ56Ghu6JpM64YuhTq1tcV8Np84wXpnU2gJ5AVpu3uWB7T7QU7mGF3QrCEFiM7wmYRzNZDX7S0TCqA8Krot2THLOViZvrC0c0Q+qucTJgyN2m2yBdg0QW7QXtClHBHGHgAewB1GGTuYz/qd21p3jHX/hvRkn1NCriQwJ96aPfaTDXsCgrh5fdbRWb27G88cLMH2PHqLMNzmvFWq+BSmGPkkjE6GxDTpNlQGJLxrsZMtKbdPHQO7m1gckXszyP6UYbskKUwofeKb9s448/yZORY7bo56FcMYdIS3+d6YFazgbXhdNptNRoDQVjChA7qYg4dRjDaQLbBbBK9BwOCEU7uTax7mffVNrib9h2HyjqZrcIjIExUVauTuPI6UAl++QLfw87gHtm8+LfVanzbGZkTI1WmBVz5vxU/mtRDbnX36OciDvJL2Vy+1DqmIui1Gb8aXtY9GP4YdXWET+FcylRhotXM4T5RGndXxw9CsY8DbNHEiqn9fkCZrYoSFToZ2qMxSNTJXizCif1dPAF77HUnQPEN3Fm/07Whpt8V4Cp/7ft5rXMs5QismKHBd5poiHPNcgfrCqeo9aDHtNXAu37aIWhCV3PAEBO87lCz9fkJhBaaUSe8T7ZNSjZ44M+W7/55DaWgsfd175ZAKNC37EOhsKrW/J6QRLHWxPW4adRpgmwPUE/VCibpVQNo8eJ6FKSE2BDdK9TW4BzZLXNP5OAxInKZMzqSfm05VnQNuWulojmwcOP55Bd52lxXwFCUk5zaT7GqHo9oACi7D70hzFQlD1AS7E/sgNbyQwnhdMyC0hlkQiSELatNbRB8vUPg5a9hIuJGDLcQcHpVpAMMXE2N087UPO/FrHedZgcEjoIhsPM8vfa5cnaFhvQcy247Q/Gt+5jn2oQT/bZtDTo++8C/M9WqMKbWWC1XIKE/pv5MhEEKtr7Z+I2rdHsculxDL7bDVbrKoCzLJAVhMW79ooCOddZ/IHqL0/YqIe1VfcBz+ueiuvmLe4w9Jq75ELnUa+zQ0q0gzMpew6Vp+nhOWngRv/RR9lKhPtiLN0uYblcz7hdVnkbNmm4SSUslO6KJQWxg1zuHgDWvl8kB4+WUi3Btw5ylVWqSEcIdgv7AcH6XdKSJMnkyYmj4KI2KP0/Cghb3MVfQpHRyG3s3d4vKg8Ip5mIah16hAHtBac9SQhEKl1sPwBVRctsrJJnhM1udoRGGjaNx189rdNLHFlhmzf1xMvLtU4CJ08UBZQuLyOGVEvx+DtZmrz/qbTgHegQsh+jQO4opR7MSLEXOOPS3sx6vAdHP+M2/FUPhR2sN4agECRfOA2akwvPZdfkvXH+smYBx0AD/7uzMbkTj0f7V124fa0RFVJKbMjD5OTSAPzgtTydlEC7zYErkBolqy7OvRd9sIu1FfiXEouSrlfb/cQ6+heZcIhBc4i9w0Rd4Vu36HjCxCbj6Rk9LO959S4ASPiPf/YwR5DdFPJkpAIHRn3Odbfgjidyy7YRDwYk9zYWGvSOyx/ry+2N8PGBSXoNZfpcvLONHrHR64cMquYbihTAdTuNSswewDH3P14TUQinDytOxFUICbMf12GiUgaXHGOHQeh/wKwlrAXn0T52tz/3uqUq48nqFrfJIMohrIdNjneHW1ZG/OKbjbZJw4LN4K94zM7hrP+bsfmH97iXjpUbBsKEnwLbni6yQK04qU2r9WS49NIuvZQff34XZELPei5tq2S09nAFtEJ0dUL8hF6ZGzBDkdgt+LKBWw6xkLcuhYY1RasgTy9HyMPHVFJKICxJwW3a2LrmlkzdGO/Z4H4UfYeKib5/+xtZKRkekX1ou4mei8Wxr6ZUGzf35xMyxY7EQ1uXFO8ClIX9qnOk9Sqjk+MqAKG9fbANZRpi8pgoyTENdHTwogIR+E3tgTQkbXok4vC1/IwweNZB9jWPPHtwzJ5UfldWGMgCMq6BzwcYmDBy+yiEKWbXojNk5o1PTH2g65d+JTh2KYZdvngNoI7UrjcxbvuWu7IKYzj6VdhTVaTSQAP27cDsO9HWni91cABd/uYHGKLdg9Qr6WQD2NJJH7wLdvBZZ+/8PaCx7yEagjIOkgePZywjF7GFPZPLtaRIKFFw57xQAFtkYNSLlGUeebxpRILLKSrJQNFC4hQdrhfIXgG1SkKMzrh9NnHwbWZ+vJVBkoJUTMLC/kEfqfRkyVkOJ0Q+24rC3EA1pibF+a2BTk15Av2ziFblDx8Jvs71YEcdUtf/ld410wlfmJpliwY0Wl28KaJTvk0sbYPtPYEBVR+20GSbleOKYTmxCcXN2tP2beDxdmvM4Ttejy6FGh3QZuo7KrVC9AIjeTIic9T5iEEVWdnIxGe5i7ljfat2bdsls+/WulU5NTcQ6k6GwAvBrPU8fvCNR2/sSLT1YE6Vgu/sxnjTCkQTjippPjL+1kKUSSuahbtAMmDLtmznloI3poZzOo4K4/1V7z2GH906DTVxmmoRHddyvv6tV6mbi5knNMsdnTinTDioTsrv5zoxXNJWCq4NYkRJkj4ITy4ihOfaOjQWa2nERAmdWeeFXUsm1O4+pbe/uU+wyuExmXla07iinr323CByJPfl7glfB/By0S1Gf6xwCaKiDQv7REkPMN01Z+jNMJAfccYQq7Dg6cqHBcLbP/Gb5YLXI5mh8ktn/OW7hSj18429LQcGhyh/vWF309bLl13P45kGV9UZ5Y+8cMD+qHr+Sjp/nX1iyMF1xYnMXNWYLkucg90EhgPZ3YptS39Jq8pyISX1Ym1a69T2b3aJ281BFpX/zkoAeJ6DTq+4QtZ7qSoafI8GjK3xJRE8jg88sdJShvwEHvwuDDJ9AdGsGn5aQEFaui9w72If1UuvA6hetb38QlYRmgn01xkqNXE33hJWVK45ZgPnuh0ia7zOtP4q5N9ZYLB1bhyDpHUM/EyYbxZjeb/yFJcKwOONiX+uu6RfL5WqE1oYoPLeTO8qQIWc5w/ykhsu98F5kloWkvPjZKPol3RvHdb6u0i3A5iRQlAUO3A14egLflGb+F2hAF11hT2paW+COjQRTcmaCyrxupK7lMy3yo4WfgccCz/c3nGrGNV5faUX2Zf2B6NPXsGInbY85hQwKPkROhRAw2vHQf2Dbn3E05TnzjhfCTW7dyduq1jQ7/U+VbWoSV+HTVDaLes32d9q61581J9H8wliGecOQD58lT6XS8GEP5jye23O19Hcd478pVKSGe09GblguCcWkz/CCdWw9DKcKw3HjGihLyL3FwSGDUhS43KnkOkoy/EgKLrzj+nbFmSDey0kLboBtO0dEyyzGXwO3s/fMi0aPGR5fTAhOBNzOfAEtBxu1clFEGXbk4PRCb8fvRXXKEk7Jh01T0a7CaSsQySkBaUzcvzqSwC+2mcyvnoCL8g5gLwYykckL/vRTPb4x2OsZ0sq3aPLSdKX8q/dWwCblk8Rmv8llgDwlfND0ed3j70+JCo5uVgba4Ax0B+5q3mRNtUsU4vVt3zThErt1mKQ1Q4VvbmH8L1IPLjDtP6RLK++B3S3LFoemcrtFB5lLiW21JcDiM86Zxq1v29cMjWrlAGVh+v4d59E6R1etLmo2FZ7lCuKdGN/Ykh+wsmMzlDDbjRmpAUJn0ghVMQ1+AjiTftpEFZcq1mOVP6Y7PCsxPNeytq8cvL6WrGF7lKcdKcQSjS8Nfle5/IDyWuE0oBYrGBiN5mQEhRvT10st9Z7/ppe/86RcWbpF40sZ24ClBC8z0mj5KivtislVSvxXortar+niykICT70HGIQHgk/S6ZGKuSS7sPuI9smlrkjnT4vffZqk6MIWnxjrKAVoNrZmm8tbEdTIIjGae5vzi1UHZq4WKMqdmX+9W5EVwXNBCX3LxEk/4hqO//e9bqrkqbrr+bIKare3BM2mImMktWUnsNeOPKqSZthDeinccNRkJgiWsmRfla9teappz6m6NSuGhmw8IR3h6frFdDEOJ+cr0fBVc2G4YT+WFY49XMLWZCIy9kh5KUe4bCEpJuP3UKLHJo+kVpWLqvbZMfM7AHOQ0GjHDol5Mh9Y5xUjxSQSDrRstNuXXH5U4ctDGtecuVLeGdAhSzB4uno5LIy8iMIq/Ym60GeGgf0yq/2pNXlvHkru+7DpT44Gy6Gmov020seUeBXwnL7LPLY8iU7Y4KwDsIn/jnEu0tB1s8Fbdz1HITQcMHhO/iRoUWLSG0Zs0cIOfL/foOAxvXGotzqnybe3AmS52Lcick6yZEox97/3zM9/c0Q2RTzGylWoTl7qTs57XHENvL/sI1Pt1pwFWArDhXpp3cVdnJHU2/EkZvS5jRoiDpDgfA0IWAsnU1BN0H8IJcdU6Jy4CVnXcq5L/AXE9Hk0Kj8jHznFIQFTfGFtRbu9WHxh9BVai+mskbb6HdZZ9qaVkfng4Uo6XZ2CEBToQmOTn/0IHzHI7Rz0rbCmeFIlbK2Mx/5fsgZ21cmBAE3dya7lBBuEptwZpEKYaTmKcbatd5ktrzQRDFdQHuvLmMzV460aW2IIeFij9tH8K1ePvMqgGvAwA23Nv3eIEv1yecsi6iIZSNSoEy6nlEv7PcJZdMD8KeReGdK4jAnnqnkKAHZ3Dc3vpu1z22e/7W8v4cK5iYhtHWnCRncjW5g5oBzohUypiE2xX1jpCXRm6SJudCOdOSGwNkYlDNl/+VrPQMqyZ8t/X/z6BbMVguUM9KVtrnHu7V6QEXj1ypXL/nDmItxja74Zl6sywi2T19ScY69qW3rr5nMInadm6DvUtnqbN4QsKROtcsCv0IGXByb3pSN+tW6iJ6JXXtp+VaDU3yjf3mjWO1ohxEP6JALalotf+KLtM8Osv7lAUJWvHgTyvLfM+uiBX/ux1TQ7W87sfp8ue6b1k+bEkA5Nz9935aRWV05HTTP7gncx3nJaV2Wpn7/yIxGYDZZgEHbcVLKi/Nc1qSD5f+M7SXHk0YvvhKoj/9R0/By3iv1It8F3nsLYr3E/6gtCki1HTPQOX2X/uOEDzRCKYBhrnInTFhVKkuRc9YCCU5c/4+FrzT6/BvUTkMASmG1/5iByiKsY7BTePqlmOqBt13AUiUwfloyDaRkvWqKSszGx/774ye+H0ZmP3vlFL79vJ6qh1Am5aJK6muMHkCTQXKXA+YfWs5QSIEqO2UiAYU5FHVyJV9lkynz4bHcsyEMg1gW1ct/pElm3Q9txWyv6VQcA1+dlGJVHFL07PjpHrdv64GR9gcIa6JGQjvaGZ2OAkTlJf5g56Io7vfi/C7vTDDKlJ5CpK95P+gm5+vXvIPjatwF87YT4KBDCeTHGf7mdRog/CxPwMHbiAVQbrvJcx6rnALjmeIGFOUWHTT25DTJIDLpQD1JCYoVZgTZ4/3vHkvxy0teyHdGeXbPrIEqpGk94hXvlRKVl163kNcnj6g77LTk8So6ldOgA8eFCxDXu8CzaByeceGFHeSUFuSgPv+qiNx+scceY9Leo+0sZMUkQZ6+O3rwAwkyU0x4uf6Yny2rcyahpq4oCp2wgq38Bv8GqrV/91fdkVkQB+8chddZA4lUyULcm3LoyUsXhDQsw1Vj5oxeaK/aeghNkXFHS5xepX1LzFksg0sOaPgk4rHh49118YaVDQNZF2/jz7MZIhcoPIhlq1Ch9jFEqEju/otWhw5vGicstrUH7JsxeHBweikp1L6RVLN40HQ9zfdJVRoZM4z1J0Cj+WJb7PiI1rXTWOrm0iawx85SXxYOmx9lgcRSYdLS4GBtrW0YGQCCRh6SDUV5kZA9KmtcfKTR+BEpl7oroN7oVbdDzqduV8d2S6U7KfZbWn2nLVEcjWHB+zyWLrevI7LrNhvxCBMA/vP9zBxhvjL1jESXy1akNRjMTowdmCgwPZNgtbxUt4j0ZfINDuu2TOiWVuNTaqBhtJKL8xQdYlErq5AnEF0JcqBlvHB0lE0fTJj8xC7BroYDFULsiRNZJ+wtcidZg7Frd3sTzAV81CyrlS2CNRdhUOEAJmjYfa9kKA1hO2KIUzHMGePXOyTfh4Y78/p9y3WtynkqsWlNw/fJIsW2OGCtuPWyLsbq5SQayA/2ZbrOdQDXz55EjUciTkuGXJlNs7H41atEVFH5XTWGh7xfpSzjEoRBYoVzMsw7vwiCXjTp09tzjFAVmo8pehZkdtdBmu87M5rs8LjLauWpHrEhvML/5zdXHGY4cyB/gx6fLmh2EPoPLhKwfYZKGfWTM6j9hXxI/6OnuboBp6dxe6lUYfFqiDdzHCEShnqtYdG4fLohQXQoY9z4iOJAuWGAVYEPa3cXjm28lkM3475YwZls8wUOdKHkZlkoCFMfkc7uR86hUNRpROmm8P5YN88k1JHur2Y9ytOOmECprAvvpSZKdP6Rlnxlj8/Ig/defNe5KB5R9WTJYegva7BrIKjLaENb0K7+aMz/CkhsTyO1cIUumpzdV4b/9iCtCZp2BZAVAZwuH3Vvvyc9GYb+IlaEh4gD5iLTwQ33/VRY2loE7wwHnjwxVKUZTIBgPiTpcueqh9j6A1tVDSTWpLfDhIqQHUiKS1T+PN7gOeqsITEpCWc9ogrdVG9k1OxbA87vam9Ni7297gJJFGSeHWagnxF6a/jy6ZdiwxKrwXRC1XAuUEDJV5rdCup85tjgdvUD5T/o97yCsHjISpxf8YVhj1VdmK4y17B5rGqe3W4d/9MVDILQQJEBVxLeWMHjfHK3wTLLX5yfirjHKlKhTLyWI37pJJ+BcrR0jt2EFe8yt4d2vA5I2Do1Xsu54TSel27Kcgg1zjoCLT+IhwvpugHfyh2H2w1thgkxrHOnSYrgquuh/2dE07xKWvfAyBZrLZP1yEryaezG9G87ZnzQXks6fF6A0XGQd6c8z+JCmolG6g0yiXlTN6TqjpSRmrf9b8U1OEBTkvc6DZi82JTzOdJTIYFDyq7MOXD8rQ3NU7aF+U++cC6B8b+wHE4MiRExFc/jso08tsCMWc1QROA6MZfI+ra9hB0wSOE5TNFxGwnkvLzDsmxfxsk7ERUzM1c03vl6PI45ch1uXYqX4qXCnrg4GF0hNPF2p+5h/DvhFhBAEhcyFM8dU0n5LsaTZ6Td1shbhm44yJ+Cc4BpAhIziNO7QQdGOy9mXMLXYqCQp19Tfjdvnkbc+THdjcn2bleMt3/jZh5xprCFVcKkCeYqkEMVSuN1YhaeZq28uaK2vHXbfN2AvPNm4jvJgO9QnphDY6spW0H5WR358POH2q6BsCOWbJi2Wu0JJMZN9cDBADDH0kNXd3DsUU8stc/1iYA3D+XwugSI6h4AAHrityhKruk63NlS3y7ZiCsHA3xnDyYnLRfh2xCn1W5vSP0MorBfb1Z1VsiIYGVGWQOHEXJSIxu75YfsJdlDa6xkbPoJeHEluzk0jjKybPU6n+siGbPLvlAFQrA0DbtbAqpfH/dIgiQPrAE+X9ayaI/07rwQD6VZRwPeE1/C2q1qqJYuRv2DwP7aEFAzdVoMYKRO6gaIjX3xVcUzGPbcatpJjXhovDvehy3qwdNS+moOza8CerasDgbC0AY1Yu18Z9g2+M0KxM8OwvzgcFljc+ECTikf32r7lv0mD5+eOscattMfOMaL7boHrjWcBAnuY+0vyN61oHEwS2gseqUC7+5TGXV6KpecMd54+6E0hGu8Ozi185YjFIFd3ADhfgqiXQKYRXcNGDH/xn84JvlDhvaGWbt3rgDVjK40Oo3b/kuVfMAGt1vn2krBVaRFQMhXjykrFOi3QUCoBM+nu9C1LMVXw2NwOWc/E2AcArYBOJCNCIACciCGl/BmBkTNNfX42PU17vOJMwmuKsC7QAcN89PM04CCiKCNz3lTa4NQ5YNGkKdgq4TeThn9gfcMmkE8Rfuf/jHAnhuIDUnuqgD/MVIChmb8c4H6LpaYS24Z6VuVQEKm2Iamr3NtRWIoHKbAjjXw+VlNLfXVHmTKHPvVuy8JApfaGJ2KrjYAEMVamQuvLR1L4ZuyFS2Ws189CGpy8drPef/5NgLZ13leOTeYuLbSaE+GbNkXSpSo4UiagM8nf6yTxNlJq3Vz1MUCqETI5T1h4e2jSs0fYmOisMKJv2BdyYjnSInmDjRdxq1iwS1OjPjIOcPO1Ik+GapMt6tyPttnUz82Rec60GeGA7j91lxD7phMmuO6QSZG1LmlNpFoC37/Ppm8X3HvgVwLRskiuQm1+jGsrz4RzTzNjXGSovuVe1yvvrf/a+tL3awMKocc9BVs39cGfMg2JtOVJyL0/lrJYjVlqYI26F90bHbyQ5mFDpx/dMitQp+e/QekhFQdHS2rGl/KQIcbx9T80pOPl1exXKA4tWz+Daar428MsvCUIlGZio5DINOcQFb70fpa3jmKbtYLI1Ga6HxOOf7QYMYeYqVmmPGLL7PC0fl/Wuavxos3c3QzrtxoyM5j5/mFSvJF6Dr10axq9suDjgKHKZL06A04dHeu3qbmn4dB1S/2K6v8Iw2E0Ewt2mBSwvYr23ykWKcyRsPm4NnEyr70JTxHkTohHll/wH98wayXsW11QqpnbPSqO5jOEiY2/JqkOZHF4wFb1kzs66Hpdl7x54VJwWEwqiweaDibBZzqqWbC+/yV3rxJ46J2KHLxfW4Ss6FnxDDqiWMr2VAZfRaAv4oY1ue7VJwfikW2Cljxzqa4qvc/NEe5RVt8VGpH2U0n/l1W9GuJWOp10rHov4/KaRGgC8Ist9meoQriK5acOCJXjJbbXk/Nx48nXZFYc2oWdYkTEKO3AUO2jqFy5m7Xxy7Ll+SMjy/8jZxU/0VuPAT9m1EbI03bSLX9Fi584LwfrTjaxo6RneVnm7po53nwV6aivTxHjQENnwuA8qPzqJdgIPKxRnYpTJW2/5cVsASAvqNo6V/uhaSj3UZT0m+85OL3RkXbVGOFzs5GtDzWUg3mbttmv0l7oTmXOuF1JLHTHdx/Xl3iNufgrtyTC8glbrIp4fOgt7aTmw+uCUqszIE5CycN70Blno0ePHD/rGDtRx4QZSVwKF5C09nr9Z99emhAGlGs/YIn6/dbWYeEBK66jo1jBinYRdA57Kj0bUxeN4UU9w3cyZpuD6j+NNIasauNzAgERcbD/3EFPOGWsoNT0izCqwaPz19PxgpSwM5I+RSwZkD8mrg//IHVNjqX91c9cwjaMhrMHJJdWbnLEOK3j9lvdozOP280FJJhzpxjKjAZqe+a0Vk5LVyVMioaRn+WEWPZ64Y5mG4J6xvca3X+dk7UL3yeJspKEWXGY5ic/YT98GbxSfpScUHu4CQFjvxAbNQYTMDaO/EMx15EBTDpubm9XxrDzQFJVwKJDgML+UbMAGG2oP/9Icb+fIx0BsDHOQ89d4NoHWkuXT0aYaCKIoaGdPQ4V5tYmgdDx0cjjXpR4UJuwBQQNM/nz05KbWBX6cfGs58eoeH9YA8ielfIoCQr1s2Q5KZc3xnnwYoHknB4banFuaBsMjqKShdHbH/kh2GV3uvn9PCMWK0dcBIsbAAAAgTMHrg/X7YAsonF0PyUkYnZmFT4IHYqQ/Xk3wSZwbbFEEvXO//sWJhoSoW0JqaTepSbiFmKgvlSULDByZCXlPKB9oY5Nh01y5WDVarZo7ql0fUKSCesjnmnbadMPEFN3WBqVdCikONrQ1xjJBxFOxn371AbCmNTVAV8dm/gpgquHyFLKvkywJFu4y1YDXnsvnoZibwVW5kerhlGf0ZT+MEpmxP3pi79gS7gR3Cj8H9KwgF7VeEi8dM8vwUCs6Z5wI0eCwByLIjgkTDpCsge+4Z+lKhgDSz6Sz6bFwzLV93uiTxcGwBlDAQmA5AAHCwEAASMDAQEFXQAQAAAMgYYKAe/6714AAA==; VarID: ---
Type - Grafica - SymbolApiHeight: 0 m; SymbolApiLength: 0.00163 m; SymbolApiWidth: 0 m; SymbolHeight: 0.0008 m; SymbolLength: 0.00163 m; SymbolScale: 1; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniModQf61.01
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniModQf61.01; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Altro - Famiglia: LFX_I_IguzziniModQf61.01: LFX_I_IguzziniModQf61.01; Famiglia e tipo: LFX_I_IguzziniModQf61.01: LFX_I_IguzziniModQf61.01; ID tipo: LFX_I_IguzziniModQf61.01: LFX_I_IguzziniModQf61.01; Tipo: LFX_I_IguzziniModQf61.01: LFX_I_IguzziniModQf61.01
Elettrico - Circuiti - Dati elettrici: 0 V/1-25 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes
Name (LFX_I_IguzziniModQf61.01:LFX_I_IguzziniModQf61.01:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
8659694 | L00 - Piano Terra Piazza ELETTRICO | 3894 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8659727 | L00 - Piano Terra Piazza ELETTRICO | 3895 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8659760 | L00 - Piano Terra Piazza ELETTRICO | 3896 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665070 | L00 - Piano Terra Piazza ELETTRICO | 3897 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8665082 | L00 - Piano Terra Piazza ELETTRICO | 3898 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8665126 | L00 - Piano Terra Piazza ELETTRICO | 3899 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665175 | L00 - Piano Terra Piazza ELETTRICO | 3904 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665186 | L00 - Piano Terra Piazza ELETTRICO | 3905 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665204 | L00 - Piano Terra Piazza ELETTRICO | 3907 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665350 | L00 - Piano Terra Piazza ELETTRICO | 3921 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665359 | L00 - Piano Terra Piazza ELETTRICO | 3922 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665368 | L00 - Piano Terra Piazza ELETTRICO | 3923 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665377 | L00 - Piano Terra Piazza ELETTRICO | 3924 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665390 | L00 - Piano Terra Piazza ELETTRICO | 3925 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665401 | L00 - Piano Terra Piazza ELETTRICO | 3926 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665412 | L00 - Piano Terra Piazza ELETTRICO | 3927 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665423 | L00 - Piano Terra Piazza ELETTRICO | 3928 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665784 | L00 - Piano Terra Piazza ELETTRICO | 3930 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665814 | L00 - Piano Terra Piazza ELETTRICO | 3931 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665865 | L00 - Piano Terra Piazza ELETTRICO | 3932 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665867 | L00 - Piano Terra Piazza ELETTRICO | 3933 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665878 | L00 - Piano Terra Piazza ELETTRICO | 3934 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665880 | L00 - Piano Terra Piazza ELETTRICO | 3935 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665891 | L00 - Piano Terra Piazza ELETTRICO | 3936 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665893 | L00 - Piano Terra Piazza ELETTRICO | 3937 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665911 | L00 - Piano Terra Piazza ELETTRICO | 3938 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665913 | L00 - Piano Terra Piazza ELETTRICO | 3939 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665922 | L00 - Piano Terra Piazza ELETTRICO | 3940 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665924 | L00 - Piano Terra Piazza ELETTRICO | 3941 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665935 | L00 - Piano Terra Piazza ELETTRICO | 3942 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8665937 | L00 - Piano Terra Piazza ELETTRICO | 3943 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8666051 | L00 - Piano Terra Piazza ELETTRICO | 3944 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8666060 | L00 - Piano Terra Piazza ELETTRICO | 3945 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8666069 | L00 - Piano Terra Piazza ELETTRICO | 3946 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8666078 | L00 - Piano Terra Piazza ELETTRICO | 3947 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8666089 | L00 - Piano Terra Piazza ELETTRICO | 3948 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8666098 | L00 - Piano Terra Piazza ELETTRICO | 3949 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8666107 | L00 - Piano Terra Piazza ELETTRICO | 3950 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667196 | L00 - Piano Terra Piazza ELETTRICO | 3985 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667241 | L00 - Piano Terra Piazza ELETTRICO | 3987 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667293 | L00 - Piano Terra Piazza ELETTRICO | 3988 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667304 | L00 - Piano Terra Piazza ELETTRICO | 3989 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667313 | L00 - Piano Terra Piazza ELETTRICO | 3990 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667326 | L00 - Piano Terra Piazza ELETTRICO | 3991 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667335 | L00 - Piano Terra Piazza ELETTRICO | 3992 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667344 | L00 - Piano Terra Piazza ELETTRICO | 3993 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667357 | L00 - Piano Terra Piazza ELETTRICO | 3994 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667368 | L00 - Piano Terra Piazza ELETTRICO | 3995 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667377 | L00 - Piano Terra Piazza ELETTRICO | 3996 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667386 | L00 - Piano Terra Piazza ELETTRICO | 3997 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667395 | L00 - Piano Terra Piazza ELETTRICO | 3998 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667406 | L00 - Piano Terra Piazza ELETTRICO | 3999 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667415 | L00 - Piano Terra Piazza ELETTRICO | 4000 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667424 | L00 - Piano Terra Piazza ELETTRICO | 4001 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667433 | L00 - Piano Terra Piazza ELETTRICO | 4002 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667444 | L00 - Piano Terra Piazza ELETTRICO | 4003 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667455 | L00 - Piano Terra Piazza ELETTRICO | 4004 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667466 | L00 - Piano Terra Piazza ELETTRICO | 4005 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667477 | L00 - Piano Terra Piazza ELETTRICO | 4006 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667486 | L00 - Piano Terra Piazza ELETTRICO | 4007 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667495 | L00 - Piano Terra Piazza ELETTRICO | 4008 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667504 | L00 - Piano Terra Piazza ELETTRICO | 4009 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667515 | L00 - Piano Terra Piazza ELETTRICO | 4010 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667524 | L00 - Piano Terra Piazza ELETTRICO | 4011 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667533 | L00 - Piano Terra Piazza ELETTRICO | 4012 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667544 | L00 - Piano Terra Piazza ELETTRICO | 4013 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667553 | L00 - Piano Terra Piazza ELETTRICO | 4014 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667562 | L00 - Piano Terra Piazza ELETTRICO | 4015 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667573 | L00 - Piano Terra Piazza ELETTRICO | 4016 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667584 | L00 - Piano Terra Piazza ELETTRICO | 4017 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667595 | L00 - Piano Terra Piazza ELETTRICO | 4018 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8667604 | L00 - Piano Terra Piazza ELETTRICO | 4019 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8690096 | L00 - Piano Terra Piazza ELETTRICO | 4190 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690175 | L00 - Piano Terra Piazza ELETTRICO | 4195 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690184 | L00 - Piano Terra Piazza ELETTRICO | 4196 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690193 | L00 - Piano Terra Piazza ELETTRICO | 4197 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690211 | L00 - Piano Terra Piazza ELETTRICO | 4199 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690222 | L00 - Piano Terra Piazza ELETTRICO | 4200 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690233 | L00 - Piano Terra Piazza ELETTRICO | 4201 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690244 | L00 - Piano Terra Piazza ELETTRICO | 4202 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690259 | L00 - Piano Terra Piazza ELETTRICO | 4203 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690268 | L00 - Piano Terra Piazza ELETTRICO | 4204 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690279 | L00 - Piano Terra Piazza ELETTRICO | 4205 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690288 | L00 - Piano Terra Piazza ELETTRICO | 4206 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690297 | L00 - Piano Terra Piazza ELETTRICO | 4207 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690308 | L00 - Piano Terra Piazza ELETTRICO | 4208 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690319 | L00 - Piano Terra Piazza ELETTRICO | 4209 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690328 | L00 - Piano Terra Piazza ELETTRICO | 4210 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690527 | L00 - Piano Terra Piazza ELETTRICO | 4219 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8690663 | L00 - Piano Terra Piazza ELETTRICO | 4220 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8692000 | L00 - Piano Terra Piazza ELETTRICO | 4283 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8692013 | L00 - Piano Terra Piazza ELETTRICO | 4284 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8692024 | L00 - Piano Terra Piazza ELETTRICO | 4285 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8693863 | L00 - Piano Terra Piazza ELETTRICO | 4373 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8693872 | L00 - Piano Terra Piazza ELETTRICO | 4374 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8693881 | L00 - Piano Terra Piazza ELETTRICO | 4375 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694129 | L00 - Piano Terra Piazza ELETTRICO | 4376 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694209 | L00 - Piano Terra Piazza ELETTRICO | 4378 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694222 | L00 - Piano Terra Piazza ELETTRICO | 4379 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694231 | L00 - Piano Terra Piazza ELETTRICO | 4380 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694240 | L00 - Piano Terra Piazza ELETTRICO | 4381 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694249 | L00 - Piano Terra Piazza ELETTRICO | 4382 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694260 | L00 - Piano Terra Piazza ELETTRICO | 4383 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694269 | L00 - Piano Terra Piazza ELETTRICO | 4384 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694278 | L00 - Piano Terra Piazza ELETTRICO | 4385 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694289 | L00 - Piano Terra Piazza ELETTRICO | 4386 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694302 | L00 - Piano Terra Piazza ELETTRICO | 4387 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694313 | L00 - Piano Terra Piazza ELETTRICO | 4388 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694326 | L00 - Piano Terra Piazza ELETTRICO | 4389 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694335 | L00 - Piano Terra Piazza ELETTRICO | 4390 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694344 | L00 - Piano Terra Piazza ELETTRICO | 4391 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694353 | L00 - Piano Terra Piazza ELETTRICO | 4392 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694362 | L00 - Piano Terra Piazza ELETTRICO | 4393 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694377 | L00 - Piano Terra Piazza ELETTRICO | 4394 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694386 | L00 - Piano Terra Piazza ELETTRICO | 4395 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694395 | L00 - Piano Terra Piazza ELETTRICO | 4396 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694406 | L00 - Piano Terra Piazza ELETTRICO | 4397 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
8694417 | L00 - Piano Terra Piazza ELETTRICO | 4398 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
8694426 | L00 - Piano Terra Piazza ELETTRICO | 4399 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
8694437 | L00 - Piano Terra Piazza ELETTRICO | 4400 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
8694448 | L00 - Piano Terra Piazza ELETTRICO | 4401 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694457 | L00 - Piano Terra Piazza ELETTRICO | 4402 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694466 | L00 - Piano Terra Piazza ELETTRICO | 4403 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694477 | L00 - Piano Terra Piazza ELETTRICO | 4404 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8694488 | L00 - Piano Terra Piazza ELETTRICO | 4405 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699177 | L00 - Piano Terra Piazza ELETTRICO | 4530 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699186 | L00 - Piano Terra Piazza ELETTRICO | 4531 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699195 | L00 - Piano Terra Piazza ELETTRICO | 4532 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699551 | L00 - Piano Terra Piazza ELETTRICO | 4536 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699573 | L00 - Piano Terra Piazza ELETTRICO | 4538 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699593 | L00 - Piano Terra Piazza ELETTRICO | 4540 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699602 | L00 - Piano Terra Piazza ELETTRICO | 4541 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699611 | L00 - Piano Terra Piazza ELETTRICO | 4542 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8699629 | L00 - Piano Terra Piazza ELETTRICO | 4544 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704755 | L02 - Piano Secondo ELETTRICO | 4762 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704868 | L02 - Piano Secondo ELETTRICO | 4763 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704877 | L02 - Piano Secondo ELETTRICO | 4764 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704892 | L02 - Piano Secondo ELETTRICO | 4765 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704905 | L02 - Piano Secondo ELETTRICO | 4766 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704914 | L02 - Piano Secondo ELETTRICO | 4767 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704925 | L02 - Piano Secondo ELETTRICO | 4768 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704934 | L02 - Piano Secondo ELETTRICO | 4769 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704943 | L02 - Piano Secondo ELETTRICO | 4770 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704954 | L02 - Piano Secondo ELETTRICO | 4771 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704963 | L02 - Piano Secondo ELETTRICO | 4772 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704972 | L02 - Piano Secondo ELETTRICO | 4773 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704985 | L02 - Piano Secondo ELETTRICO | 4774 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8704994 | L02 - Piano Secondo ELETTRICO | 4775 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705003 | L02 - Piano Secondo ELETTRICO | 4776 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705014 | L02 - Piano Secondo ELETTRICO | 4777 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705025 | L02 - Piano Secondo ELETTRICO | 4778 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705034 | L02 - Piano Secondo ELETTRICO | 4779 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705045 | L02 - Piano Secondo ELETTRICO | 4780 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705056 | L02 - Piano Secondo ELETTRICO | 4781 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705067 | L02 - Piano Secondo ELETTRICO | 4782 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705078 | L02 - Piano Secondo ELETTRICO | 4783 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705089 | L02 - Piano Secondo ELETTRICO | 4784 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705098 | L02 - Piano Secondo ELETTRICO | 4785 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705107 | L02 - Piano Secondo ELETTRICO | 4786 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705116 | L02 - Piano Secondo ELETTRICO | 4787 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705125 | L02 - Piano Secondo ELETTRICO | 4788 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705134 | L02 - Piano Secondo ELETTRICO | 4789 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8705143 | L02 - Piano Secondo ELETTRICO | 4790 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9415954 | L00 - Piano Terra Piazza ELETTRICO | 5055 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9415963 | L00 - Piano Terra Piazza ELETTRICO | 5056 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9415972 | L00 - Piano Terra Piazza ELETTRICO | 5057 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9428077 | L00 - Piano Terra Piazza ELETTRICO | 5058 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9428110 | L00 - Piano Terra Piazza ELETTRICO | 5059 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9428119 | L00 - Piano Terra Piazza ELETTRICO | 5060 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9428128 | L00 - Piano Terra Piazza ELETTRICO | 5061 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9428433 | L00 - Piano Terra Piazza ELETTRICO | 5062 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9428493 | L00 - Piano Terra Piazza ELETTRICO | 5063 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9428531 | L00 - Piano Terra Piazza ELETTRICO | 5064 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9429992 | L00 - Piano Terra Piazza ELETTRICO | 5069 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9430001 | L00 - Piano Terra Piazza ELETTRICO | 5070 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4
9438172 | L02 - Piano Secondo ELETTRICO | 5107 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9438188 | L02 - Piano Secondo ELETTRICO | 5108 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3

# IfcLightFixture: Lighting_WallMounted_LineaLightGroup_Quara65_RI:92671M70 (60)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Linea Light - Metal - Grey, Linea Light - Glass - White glass
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: Lighting_WallMounted_LineaLightGroup_Quara65_RI
Type - Dati identità - Installation instructions: http://static.linealight.com/static/LED-FGI023.pdf; Nome del tipo: 92671M70; Numero OmniClass: 23.80.00.00; Product data url: https://bimobject.com/linea-light/product/Quara65_RI; Product url: http://www.linealight.com/en-gb/family/quara65-ri/84274; Technical description: http://www.linealight.com/en-gb/family/quara65-ri/84274; Titolo OmniClass: Electric Power and Lighting
Type - Elettrico - Commenti sul wattaggio: 1
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: -90 deg; Definizione sorgente d'illuminazione (famiglia): Cerchio+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; Emetti da diametro cerchio: 0.0325 m; File diagramma fotometrico: 92671M70.IES; Filtro dei colori: 16777215; Flusso luminoso: 219 lm; Illuminanza: 1.87588 lx; Intensità luminosa: 17.4275 cd; Rendi la forma visibile nel rendering: no; Temperatura colore iniziale: 2700 K; Watt: 1.47433 W
Type - Generale - Edition number: 1; Brand url: http://www.linealight.com/; Date of publishing: 3/23/2017; Design country: Italy; Manufacturer country: Italy; Manufacturer name: Linea Light Group; Nominal height: 0.029 m; Nominal width: 0.07 m; Product family: Quara; Product group: Wall Lights; Product SKU: Quara65_RI; QR code: http://bimobject.com/linea-light/product/Quara65_RI; Region Africa: MA, ZA; Region Asia: AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; Region Europe: AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; Region Middle East: AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; Region North America: CA, US; Region Oceania: AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; Weight Net (Kg): 0.098
Type - Ingegneria elettrica - Voltage: 230 V
Type - Materiali e finiture - Material 1: Linea Light - Glass - White glass; Material 2: Linea Light - Metal - Grey; Material main: Stainless steel
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_EnvironmentalImpactIndicators - Reference: 92671M70
Type - Pset_LightFixtureTypeCommon - Reference: 92671M70; TotalWattage: 1 W
Material: Linea Light - Glass - White glass, Linea Light - Metal - Grey
Altro - Famiglia: Lighting_WallMounted_LineaLightGroup_Quara65_RI: 92671M70; Famiglia e tipo: Lighting_WallMounted_LineaLightGroup_Quara65_RI: 92671M70; ID tipo: Lighting_WallMounted_LineaLightGroup_Quara65_RI: 92671M70; Tipo: Lighting_WallMounted_LineaLightGroup_Quara65_RI: 92671M70
Dimensioni - Area: 0.0137151 m2; Volume: 0.0000464797 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO
Name (Lighting_WallMounted_LineaLightGroup_Quara65_RI:92671M70:...) | Contrassegno | Host | Quota altimetrica da livello (m)
10709997 | 6354 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.0678863
