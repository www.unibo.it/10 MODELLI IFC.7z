Properties of the parts of a building model (IFC4), part 19 of 23

# IfcLightFixture: LFX_I_IguzziniMod.R671:LFX_I_IguzziniMod.R671 (108)
Name (LFX_I_IguzziniMod.R671:LFX_I_IguzziniMod.R671:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
8707702 | L02 - Piano Secondo ELETTRICO | 4861 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707729 | L02 - Piano Secondo ELETTRICO | 4862 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707752 | L02 - Piano Secondo ELETTRICO | 4863 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707774 | L02 - Piano Secondo ELETTRICO | 4864 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707805 | L02 - Piano Secondo ELETTRICO | 4865 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707814 | L02 - Piano Secondo ELETTRICO | 4866 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707841 | L02 - Piano Secondo ELETTRICO | 4867 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707850 | L02 - Piano Secondo ELETTRICO | 4868 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9434483 | L00 - Piano Terra Piazza ELETTRICO | 5074 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9437284 | L00 - Piano Terra Piazza ELETTRICO | 5095 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9438811 | L02 - Piano Secondo ELETTRICO | 5118 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9438813 | L02 - Piano Secondo ELETTRICO | 5119 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9439113 | L02 - Piano Secondo ELETTRICO | 5123 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9439115 | L02 - Piano Secondo ELETTRICO | 5124 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9444072 | L00 - Piano Terra Piazza ELETTRICO | 5243 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9444099 | L00 - Piano Terra Piazza ELETTRICO | 5244 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9444101 | L00 - Piano Terra Piazza ELETTRICO | 5245 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454021 | L00 - Piano Terra Piazza ELETTRICO | 5322 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454038 | L00 - Piano Terra Piazza ELETTRICO | 5323 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454054 | L00 - Piano Terra Piazza ELETTRICO | 5324 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454104 | L00 - Piano Terra Piazza ELETTRICO | 5325 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454106 | L00 - Piano Terra Piazza ELETTRICO | 5326 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454108 | L00 - Piano Terra Piazza ELETTRICO | 5327 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454131 | L00 - Piano Terra Piazza ELETTRICO | 5328 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454150 | L00 - Piano Terra Piazza ELETTRICO | 5329 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454167 | L00 - Piano Terra Piazza ELETTRICO | 5330 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454170 | L00 - Piano Terra Piazza ELETTRICO | 5331 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454188 | L00 - Piano Terra Piazza ELETTRICO | 5332 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9454205 | L00 - Piano Terra Piazza ELETTRICO | 5333 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3

# IfcLightFixture: LFX_I_IguzziniModBk10:LFX_I_IguzziniModBk10 (16)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniModBk10
Type - Costruzione - CFG_: ---_0001; Mounting Place: Floor; Mounting Type: Recessed
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: BK10 : Double light emission outdoor wall-mounted luminaire, designed to use neutral white LED lamps, with Up/Down wide flood optic. For wall-mounting using the special steel plate. The luminaire consists of an optical assembly, rear base and plate for fixing to the wall. The optical assembly and rear base are made of die-cast aluminium alloy coated with liquid acrylic paint (grey finish) or textured liquid (white finish) with a high level of resistance to weather and UV rays. The wall plate is made of Aisi 304 stainless steel. Double transparent tempered sodium - calcium safety glass, with customised grey serigraphy, 4 mm thick, joined to the optical assembly with silicone. Single stainless steel M14x1 cable gland and rubber outlet cable L=500mm. Double electronic circuit with neutral white LED and highly reflective thermoplastic internal reflectors. Equipped with electronic ballast Vin 100-240V ac 50/60Hz. All external screws used are made of A2 stainless steel. The luminaire technical characteristics conform to EN60598-1 standards and particular requirements. BK10.01 - Outdoor Up/Down wall-mounted luminaire - Neutral white LED - with electronic ballast Vin=100-240V ac - Up/Down Wide Flood optic - 2.9W 410lm - 4000K - White C96A - Lamp LED Neutral White CRI>80; Modello: BK10; Nome del tipo: LFX_I_IguzziniModBk10; Product group: floor-recessed luminaires; Product Name: iPro; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___bk10/
Type - Dimensioni - Height: 0 m; Length: 0.051 m; Weight: 0 kg; Width: 0.051 m
Type - Elettrico - Number of Poles: 1; Commenti sul wattaggio: 1; Lampada: 1 x LED; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 4.5 W; Voltage: 0 V
Type - Elettrico - Carichi - Power Factor: 1; Carico apparente: 4.5 W
Type - Elettrico - Illuminazione - Luminous efficacy: 49.2 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 85 98 100 50 54; Color Rendering: 80; Color Temperature: 4000K; Lamp count: 1; Lamp Light Flux: 410 lm; Lifetime: 100000 h; Socket: socket; System Light Flux: 221.4 lm
Type - Generale - OnlyDefault: yes; ModVariant: no; ApiVersion: 132383237; ConversionDate: 11/11/2021 4:30:10 PM; ConverterVersion: 2020.2.4.0; ProductGroupID: 3305; RlxChecksum: b5a1a7c87d2c1e997de0c144376f671e; RlxData: ZN3q8ryccAANPzIlrRR8AAAAAAAAjAAAAAAAAAKurVfUAf7Yb7fCEQFjjkd4QJ1aKGDWGpUsPWGh9Xl8R12QHaDwZtMtB9++hxH5hdB/yUbcVMaWJWLsY/LJ0+F2mUFnyAk5QrSIIzjjLEQEPnebmKqthBOqlBJZ5KskzoYNW98D3hNSny0q9qMNIAyDGDcKNoQQ+Y1K1XYBByPCxEwzYOOxcK+15BSgO7bPHFpPY9i1fJVGS8uCVLrIfJP/B4NjZpuKqNmF1rRv8Rdhd9hmWXuupGV+aUJZgeHoi2w8aWIq+lsqAO/Ip7ckE3MEvu+NrhTRUnjeO2nt0AM/QbZAm+EmZuM794sjnqxHdbHsmyIGV3XHKURwyT0sw5YmZHJkYbApXLLUXJwWdj2LeiiHxGQJnm/z8A5lrAPTgGMEH8tUaekfBJ8DhPb123VuQDtZXH7+1cp0BR9EJVK0uDOROgcn7n9lY5Z2wuoBw0qTA/ucpzPsprX1vMFijL32t3e/6mUVSe4sLrKsTStMziNO5CPpAXFCz5CW2oh25jcK9PSZDuWH7ojxnfDMx3IdVVrDK7jwnuMoG1/eqLVINW5zR9p++YLFMgyqaf0gUjq6PeMw/sFxdV4ta5jXNAUC163+YSByoU6L4YH3rx0qOvWCuFzJDMwZUE+Aev2rj1pa5bS8jtGCiaCyXfsjHBOgY0CigHERdISjXMQyh6xs0BN11DZ7/qWppm74s1iuQPSwTJdqk/q8bHVEJrY1YncHEDXW5MkVdblQFj2Nlh1lKnFYLE43IQP4GUddEZEjWrU6WwnsdoxiT+l0soSd11CyszpeJn3dtj2vgdayLNKZPAnSM6JzOxhH195ENZFjAnbJWmn0MmYxONpUo39XvC/D9V8UWJF/G4CLCu+F/935KgV74Wdp6jWky4fZPP45ZfwlacbyE7v/PgK8XuzRq6tYk/bajldI4LZSxFmWoQpsjZEv7+taEXhH2TnFE8YANy7e4EyHQPLFpZ4ymlg7V2UebZ8RORsXPoi3OAAuZFMxqHMHJGWzXTTlHFk1F/MBv1IISS4vRgiLGYiPO7/u2rK12jeT30jmSvWuvyvFEgwfJTpYJFX7lXmg+eetc1A4ra8lhXopROgkFMd6HJ+d948J4XnUbAxBGA4GqEN3OCU2OCZygbntOpAuiyo/v/Kcl4AJOF83/vwI7fQGdpjkLH+3KpUhtuZftmvVE5QdUHPdZqwlqhj5VFBQYhc6gQxxhQwiNcxhMUOly64mFcxQ2JhYXBdmTjw050sHRzZ71wQNVCvdxBgSicvG5+wxvV7XFHeA1O11OCig3OaMs6/zDj3qtx9v3DvMiLLXGV3ideb10gWAUD9uzpJoBwKWaynoGNCQqiyWnrzswsrDkXbmCfjplR6LZ3Ec7kM+bXNk/79cXdZYzNQurn7KySRlVCe0PWIKh3Gi+4n8x8Z/x8OPpFoF75+oeUfA71xQbaeVI0G4MDY7/WrLn7whCxBaNAozErN0D7B39MhipwXvLNGodnt5UjByuFP79FSSr8c1Gej5lxEbWRS5uXysT9sCuAK8NLEpfdjMOfrTAdaOUBsmV9L4xuNYN+wdctN+84co9jSmgyi2PDUh6djvCOiEmv7PNA9ePG9Fsc1PY9uSnTxg+yGnM/2b9uWJL0SLIB6ezg4yxRYIB/u14smOt+pAGgftEVd5qNPmxS4/oQC9Kqeac/t7z55KirzofzgqRyngRqIbELzYtO929WIA5iv2oTeYEkKgsj82tTsxO4CJjwErvWXYj7J+cQk5UcoTijNr9cBwwPxHfTCB7msO5ZldGb0X2azcs8qnr4tF6ClAA0H6IhnzFRE0nsuxGQA9LF21zvs/RiKWtVrbwUtzZrGPPuv5NVI0UtjuQDqww6Ysxd81707S0JB3zC4UxZN9L7iOkNZ8d2wpikevURxckMaNXJ0OpGv8fQN8B47iUuQPKsxQ0wzDkN+RXY32AzdlmnloktQPeCmrlG5UBNbRDxoItI0/9tYz+hMjDB5NpvV6UPZEju+2bf/8F61EqGVxr1sSBipz8pwo+wZud6SBieZj/hzmvCv5egidFMA7f6xX16Wr3Ro7M5uc6phk7y+hcG73hS3g3NO++jeSJ53nic7M3P5rOyI0EoI5E+D1UPo2v2fDcR6g10BpZL3mPWFxnIm9A7is/tY/FocwwW2hcSbB8RNB5DQi1s4V7KXrwpD7jckQYKX40P8uYwVMrxWayDATuB0Av2C8LmNrsuX3Z9OErfZbuLV89wUCb4Wdf5VV4iCu13rxTcLoBnt6pN9GTXfPf9Pnb/O7JNw24JiXemCXhsPfZsgz4fvZKp4tFIsuIyHaCNreRAl8MNHULXtJPmQ863nUlLZ8QTS4d+YUlYGP1j9gq3Ijm4gI2ojj9PkW2oI+ZxkCM4xPRq5teOWiPbRkMeWaG2DlP4nAsQVY5rjY/SMwxyKu1JpLwi2vsbCVYcFSov3abvo2D5bgivR8x/Q7vcarH0dx+8RiI2JmMVb/kMWeiYE8oRyMZrUjSxUUMRNSkfJFYkYqB7rSW9MWi+tqV3kCS8b0NRWFWzBTf2jOVmveMtHR+1SGV/+xfeOAnY5Ln0Le1v5hcXEs9rKnhwspt1cG98wwBsjSkh1/OpCIrPaSj6TFfkPYtTbr479kfjIX+5MBWJyWkSs/9ib5LjZcv0ru3OVQijI4tq1QUk41lk/OXIzb/fdAY1G5srrHlUMZuscB3qayvaTN/5DYicaCIJahiVsydmkPbz4v/IuT1M5mDdqYhBmgN+QOa1ZCZXe283a5ALjEYxsfmMdX74QFpzmQ0IVqp6zvQ0VzmrbSv9zVbttDE8+oIt+sH9kqsXCV6rCXoP+8kxR3eOf67n9SqWF0FkM61rSR1SAXbhvNSjOoXb7ssAyP4k89mXMX8yAVQ0agWM9/rmp0B3zV1MgvbTbOuyBBrgClEpBX914JAcqKYcY79aXPDNHt5xK4CqpoXs3+rfP3yc/p7HRyELMJmjttVKwRb245TLTGokZLFqUGImpDd6kXN1JDNFGXVUfRjKwCEW3YVjyGQAw4ZK9Lui+qcdgajXzcD6Ti0oT4SIpmtk8DK2ofZM2xDcRFEBV7eeJnbsa75CRrIV5lc2mp8OM49BkbCtkEsF7pS0wn92xHGRhTlyc4T5BvL0oe6BJsQTg9oXB78ch3iju6tw3dIAvSxMXuKx0s7tu2gApjkEP04nI7MY+Cz1/1cVGcUTCGcdEI0bFCGA6OqnJSqcHTK9WHatPhOmCfg/7hrpeywXTW1RqB47zpAM4VC/3LhIDC/uQf+Y+fhPiJyACS8O/dhj4TUSjuPjzMOo63wOeezWRoDgzklEyQ86iRJmUeiF8/0ykF9LlXwjlSaCmUqwKlYnss3f4QCtuRXiqAeR2Ww/xYhKWj6k+E9q3O/oz8rQPAc1MQ4ocW/eDa5Po2UTSZw/K98eMpAUm8r/oKeq+gsf3G1qisd/Sz8MUlFMtpJsK0ELt+M8H3Xem5Vw5VZEbtVJGXbvaAm1q7bGprC0tH308jHGYlkZZRVy+b2PZ428S5jdXu3fGtV733JrlzjVjUhJRwAC1V/49qvr45OUO/dtb0LBmOCbbTt0dTDyJKGh1rAZcZ6K/5Qcb+ktYe/ZtJa9Q2W4q5g2d/VytU4+tMXDRbWbjGTPn7KEXd9kheZjPqLYZLKIbnoEn8rhbaf7FAAZsEbLxZAaJ4XekzSdcuIRtKB2s8frAu2WqqDEBW3P8PIroMhHrhd7cXXejCKW/LjQ0i2ZXT+6plS72MJbic7LmLCLfFyHOezw/dLRPrmA315ZF70b2cjePvbIxDwJI0fyA8ekXHX5WT88PjL+EujQLb+20fxqzxsc+CcaXQ9W0ODK1G7AI1k7b9LFGUBKs94KXU+jH7b7XjpuzRSmACNob55qfTQDyEO4hUseqgIpYm3FK+WEYMI6iBYMvMsOCBAjuyHpL33S3tslpirBWGOHPIC4OXpETklXUDdTTOgc+Poz2BgVXxoY1MvupyOWZ0QT3Ob7UUyA8rKNUugZNqcsiupQjkgtDlDMywG+pBuw7UpVbvb7oNbzUBd1PSdZFXB9Jt0CmMd19W97hEOGuqdm6Uh1n2TsSFigdU2ePIYP5XA8HlNakSDWHdag5IuFy1cWkTIs8l3IQmYpimQlRk8hyr4vSwk2UysnAuGHWbTmfiuJWlEchuaiJtPsQPuRrzOzNxFl/EjYMlKrcpnnCHDlycczQNSZPzAREOmP9u8YnCbKdUUcpF3nrPuglGWfzRz2pAnuqxipVDB26i799AfEXAz1b8u+JctXDfKoQqfVfDGogECmfJCXUSzA6dsdAZ2G1azQGxWJosI8f5UZqpEQM/vcR4augItkSXiJ1KWJQ7CnkIIMKAcR574DVcMYlFWCQGO84bG5MlWsDCSlEL9QRLEBBs1Ge9F/dJ1HrwNQuvmozt6Ep/XqBLWchZtsCK6V6WjVVcXKEmcUN6iLFUsm1Cjh9Yc0v+FI8byipaXb3c1+N9+bnOfZLHzTSvpnE/8zJdjJWBCtJaogIIZGZhzlrFd6fbfZJjACOneAJ0UiTvnsxoqTKdTF7xdIwjs+8yJIFhECIgup4QHCB+Ao0gUQS353DgmpM9e71ynvkyfpG9juxGaV8rFnHyYFdTaVXjcl8CrebLvfWxV7M31JWyo7XawLmj4e2U3b+6MSsf+00yvF1wyiFHq/J8qDJ1MktqKdFFPb0BPwtoMCr2GdsGKLJvp2QShkFF+HQ0/tuGPVijSnDeJPwvVpgQqet1AsOb58zFDVCelIhhOHi3tr829/3nNQ4LQ4EMziDtidKff0yAuB3OsVAKXpNtGGKLvi9l5LrZSok64On8/QdlvJ1ELsTxeShJOTgsyVS+11lacSbokjlHMtgHTzOtJ06KGOHWzf6MKASzb+OA6ncCQfdSyj3pxxYC88SSEsyUjQ0P+OQtM58jAUaiiuCdBqjenuLictA4RR+GT4+5/Z+rfOv3tn+KQzoQHYYmblYxJiXvxjTK3GE5NZk9mH0L8EtdCR+Mr8d0JVCuqdy0Hg4Wt5RSaodbg66nfaeS7ky2q0Z09GB3QydFkAsFs0T58ezr2sbFrh0ly5MeS91o9JV3QvOks1SvFpWoyaQvhe/NJhhuDa/0JqsqahbQKwNTO/7GN7+U1T3o61dyoubNMfvRHZcPTekSbr331HZyyLU2Of843SrVVAmZ/3PF4Ye2ZBFDVUAmxJYJFmLt5WcZIrh9JExbVJYXi59vZtJ8vTSUk0jEC89LAoYQqPHiM5EYZgiOPg/dMlFvNtvKp/LKfVJKKE80K45VlD4BlMoytLue8h6bfKHjlJPk6uK01P+4uQA+KNqd2qQI+UJuZKx/Wr6+9/T3DHLD6en6AcmZD67F+AELCoi6gbutn9ylS4WFuXMo4nYwOuIjJVExh8wnLfWgzGRyiDGTdRGkzYXK4oUzb79QWiKr8zSK+3aOQpPjzP1M5vbpvzuTLVamm3a9+y6PL2DcKHqF3nstIzuHrjnYkhwdM01sOpqD6TjnxUmOui11I9bpSlaCWUujpTs2KlarRwOx34UltUhsrGyEf6XgKRBKGCAADKMZwQuw6XYdNdKl1IJ1h8S/kKPnPmN16ZRfKPnLJ0dlOV8OQqZwD77R4OGV/SbX4mkKcERpkqyYkWLQ9rZ10FYZomBQCmfloEErlPZKQkOeHneYu173j1eIM4HIH03BOBnydHiwlSRyYDpnPWeON/5vk3qQ3u928Tq2H/R+4QaBl6iMr19OjXS1TeV2FFwYJm4idaAeg8mLeGbVwB68EMw4VJ7qX/fsVNjRwIRrlrwRsjnhDuwajqP89jwbnY6WPsv1WMegVfKtF2ZrlRPsMtaeqT5wXQ/d9OpNve/fJBZfWktc/OKRj6FgDrHjGYwNJ3QXZhQfjJaw20AlnyEhFTuwiNamQR2IubzXfcNakT7PzLM24sQwx83hU1mveMfWeMtJMxV4H2WHTPp9uw5M+rYTYqjiK2yD2xj6ZhwstTYhVaIA8MPQi+r2XNIOCie1LEPFCgwX1Tp1T1rw7yZlI+ZZa+Q1x+6Ns7bIunS2xtPZ+ca7b6JxgyY0x/R9Pm8yhSrG1/Vt0V6ZlERSkuBkukh7T9ixhYGYskFIg+YLhGLhihkvXOwUSRHQVDxApA8THdwET7fuSZBmnQyb5cq5mwq1DFg0ztzz7uSSr9mQqY1CigHFeUsIz5+eQZZjJK0MxFRSihLuJm+lGMdHMeBbgIIIF7AYhcsNZ+vwt87j7AaVr9ZGaVYAWgM7RnaVyLjoODBhRovyX69kiTYnICQ+5PsQacXJY9xxLRWUTBSpNZO7e3XeHnZJYUfGQpWaVt+2Wa14gUEDkE+misKlsZApaomEcA2KzORvzTOmE2p3VKM3+ew/Os77ogFPpdctFv6AiLbngqQK3zP13syqn9wDOe/7GbfdXWIVVx8UVTwewHDo6MxHOiXLmVj5Ovu378+CiulzaV8JFDTav099jcq0hjNPJBI9MIqdMNzcXTfnYcDSXH8kLtu0NgFILk8a9sev1WPrk88hgw51+EG6QzPna5+qlD9zBIhZpd9MKRQTRz5v/DwzU1qbmf5jP1CRNLcVdkQex9hk09VR9gmoDvOXXL93h5YFi5c9HhXhib217+Qgn/SFs5iLTAmnzs5wzliXF5VkA2Bss0z+KwEkMHE66vjZGa2N4NvvEdyUf1u8u2doQ57ZwA8w2EoIQcjoT5l3SFi76WskGq0NzOFBsBnTCg7W26JNzwWIzMr4xnUZa5oEfSDK+GACnomrLvkA8djpueM+1ADIIvqVuxIbkk3AnzWqPrUIaC7LwEhlcaEIF1VH56yDGZwARtrukt/FLoOQssfLQkWsCV8Jy1NaA38Z1NXiKm50LGrrnAfB6MDbqigAM2Q1XFfA7F2t9xrxspA5WP4PI2w2VRXIaiqNL5SIHk3fq6rWNtEtd6W8RYOXXDDm2fGOfLC2jaawWrxEoepjl5JAdoe3CL+a8piBNX9BUqVhP2xEpuwzEfIgS6HjGX9RjT4wGSG/HB7xPs6TUgZDsCaYMtkeOisaAKwM3hY0pXNpEOdqWHbomAOsKEEHRUjjPgVptwBszhGZtWPiqlAufLDxXSaft6KlgKoWAYz35MzwxED582JD7h60fd9sJChOs/E0/HuLORP8GUotov3RjYCpqqyY2EdYPSyh7dMktuovYvNiDC1D+oS8FF4UjKdBwZgKm0b2OQU42a1Kl3eXhIQYcyTSQbzkXnhQDThvGxLvEcRCXwc4fskySll3KW5Yy0h1Fcjvambf2a8UMmJcdNIMwH/tpou7TOvAIKnM9hs3ryQsF8cHcfC5rEBAALSdenf68DLThAAxJxlXaGoxe6JMBr9owsNpT4+eSL2q79rQtzmaOI+gLkolAjoyOkFKUydoTRZvddDR3M1jElOae9V1HK8kBpES03LIKU6FD4mKyAHonlVygt9hn1iEiYm9eJwU+aqtQJ4wylNOXtF90pnR4ceFYq3u96m/vzi+vTSM8MfGiUvTPebkyxLqzmHOlDOj1nc7lz08ixoR+t7SLZ4k5LmCPdZdVqDJ+xL87IZG/h9I8O/pANeMZtmnxVU5AMQRZELKItb3YyNJRdSdqc11SEA/Bn3vRoJ6+AXtAyhTqPTL8/9zdbEV4dBeGaoXEshIaG6no9GE759tPYb1FaPbfypKkUTEgcf46hF+IDRaDSgZdL9j8yyAcvHwtdg8Zm7WDNVKkdOQ4+WHlDCYT4us14D2l85wpfo/z46Iughy4phK0Ez+F0b7s7QLmPsuLGcBVATrFR3gLnyqhDhmHnHTA8ieVhBGg+PeUeHIYT8n3wSQ0hFwN3U1Z9LoIFqEdk9SBx0ZJpzJLqU4S1a09r0kAz4cIqtSDrorObWALR8p8SFP6iBGpVsTBqnb/WtOjTMJjY3fd2RFobzCB3Kt6YKTpJY2p+7RXhz079ctMXhUCqPvJuJVtsz4IAhGiv4e/dZa1G9jOw98sTaAb3kEL0JTRCgjIdos1SWn2rekVm6uHn3I5zf5On/MevaWw1901K0Rsk2j51qPmDLPg39MN1HzbMGsZ5uR+w2cvS9EIGvbvcszmD2gUEET/MtmxCG9w6juS/ArMLvNTF+ErUaXi07Fbz5+ALSARMox96hI0YM0WbuAefgW6MqxK6KRpKNgQP82R3n3PrTIBiM8ccN9PkyKb2lY1i9pd2S4b4vr3BKUrEpzBHSYgCgIDIyc1u1Vi7qoJzEoZj898XJlT2aBKGNYy/asmbHdMVXPsNDof75SgUXLgVngGOCOmXMLyMSPuNr69tlN51HQMkBElUS3jckDE0xgydBJYRyYowY1lgk0Qdt1zA1jX4P69nUEVwskvZOWws0fw0tIr7mU9Cw+OnozL9d7E0Ccyp90CC4B+rl44yll1BEkQc3M85TA4wknwiYW/h+yU7bFimAWeAz/HMe2Q8hQE+VEZv2sRi65gROzAqegDq0jbbIRK6jXL2RRhmyfaximZHG7tPK1pwwINhjrdLaQQsedbDG0JYo0M4v6z39D1HhAE0v0JdWjkSSOZcHyFmg02HxN2LkK/K7u+Ci/R9Lt95PDd/Xt41jR/RecBnBDRC/gmDgFAOjexlCFgw6tGgavxCb8tZxTlm851lBe+ctZSVc6806rzBt13cB8tMFd+kDXxL/p0Z1IeEjrM70nRiS8iDEF5BIYh8b5xk6n2Wos7lrhhBzD9PSi49A2BeV5ZguRSbSApGA8VZWM11nnrEeASQjPJ4J+WUeTEIGo+jBOZPYyHwfOCrfGZ+NPREPLljqijBNOQsm0pvCmZMgUAhB5UK4QU95afPbZedRbbU1gPDd4jm47em+LJctcGa5xLRbfG7K+O+A5oL/Ki0Xx8M+SEXJfRPTX/ZGwHQecL+OSQaxdGTxHcmxCm7rDCy5/a29O3b73ID+sbm0aWC33D6iS1PsMvGBRip+DybpVVkMWk6AsrWOn+YuukazZAjWCnbmMSxkSq980v+sTBUn2fCssKIgD4b2uXxHURScDy6p5EyKsLNuu3KCuYqodM/dzzn7RgXXv0ixceV/QalsmxiPlA+KEe77clE0v8jMHABWpRn6Lo4WJYblPh+CA+LYuNrtCVvPYlHCOoqlozGKzMXzhOi489pIsY0b+FwJ6Iif6svyWzUWKrTkmZL7b0QkdYP+sU7CJY0Vy9xINBh3myjJvMRc0caw8Dmlsjk0MYisQWZeYfyHEUPTPYEDP5iuqf8NJ8P4EqdyEZlCpjpRirU0wP67BWNRlLIkFegwbzu4AACUkDS3w+LBqXdCwLEZt4cYH8/0C+PiHIyq7fWdT0eeQjfznvYPAGjGwHgvy8nIp4OyOGiYGRHohcTKKpb0EsxWQYYvY8Dyo3sNJkENeuTwqaXB1OVEekVvG14si5dw38lrHWuUkhtsXkyGOR4moZCMzdKEqMDTSnsuABMyVM+G9nktfl+WrJBmLTt7ORa1OwR1H/vRXrz6CRLiwdYhfFzyTD2otCdie4+os00O3msihVn7Tkrm322XbJYQjS4hmY+AvVlUQzcRSlXMrXRwvysmw62MIKkakIrp6sT6vIoC/4C1EzDZ9RFKlp8xuKW879Bjr+QSXoJxXwzLyEhgltF6H6Pqvjbaz52tM+X+cQJspg8O4ATqZ+JEvb2DtnxNzA9WXxXUjEtqDZ2RZ2bF5VlQ7tgSAYN9pXryfmr94j+N3NvhoNygTMdydB2/bAlEyqBWNIRTNqhSiodI+1uHjVDN52NNKFMh5CzfsLW0pkO0BP2stsn8AhxTnKC/t4WA4lk5qA+jWBzRKc2uL6601b0esWCgdjvT41u4ht4nzxcqBFrIAGefjLdujXa3TNFmYukwzz++mjOCkCodavkr9xIYFqDmU/r7NBWnbUZmyErowRS3PHE6eZsWwqP1qK4SUlvcAb8obcG8bRwviXHzw33L+1IbVuCqf4bUH4TDQEJUcHv8LHaBFSW3IvsboPU5/TNjgSzrnSRPy1bDUOLLP8t6llt+NJ8kMuceWBbV3CcNZ+bLy06SeKKqK3tSeY6jCAj8yrVnNMCLFjiQrdXa1noDDp6GRQWWAXzyUUFsJ5InQ28nKKkh+J+yD/7bGMpmTq1ImojKTuQoKrKWI9Vn35Hb58KWOn7u/TdWOcdTlq7dUaITFZriX/YkIyIpNCyH4KSpZMmURG9rvg5HXcXTn+dWPBlHJSWDHa1KXTyDnkH1Sck4iIhJlms8XJqAMVo1OU3sRGLBXFdQR4sBtGHiBpsWSJ6CAXFK6iv3DHazT56/BJR10hX3uDpl37DqmHQI3lkU2A7nuYcFEBA9yRhX/UmuVP8D8lEYxBRlBzzLEjnU7sH9d+SVxjLwAAgTMHrg/WeS5LFyTT/rN+L4mSvr49CrGQ4WZDO5h8yqY4nTSZGQeWxUEfQ9vPtTSLGwBNbWUVyu1z/lSdLQOIH2dWm0QVsw8jgtNv4jOzjtXXrH0dwtslz4cszFp85jYXYrKQv5AuvSeMv5XPX72dTz2AeX56BXB29LZmKWn15tAI458TAnqugQZpPOxvgdGOhFBqTU5elgrr4Ca9BfJQM4pl5u3Rq0fjjdO5xeXK4vwJIpvPJLNS4bUAwVAPF90ZHUV9S9whaP0xLfq+Tw4RWzO/11aKOjq7hw3tFwaeaAEJgN0ABwsBAAEjAwEBBV0AEAAADIFzCgGwy242AAA=; VarID: ---
Type - Grafica - SymbolApiHeight: 0 m; SymbolScale: 1; SymbolApiLength: 0.00051 m; SymbolApiWidth: 0.00051 m; SymbolHeight: 0.0008 m; SymbolLength: 0.0008 m; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniModBk10
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniModBk10; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Altro - Famiglia: LFX_I_IguzziniModBk10: LFX_I_IguzziniModBk10; Famiglia e tipo: LFX_I_IguzziniModBk10: LFX_I_IguzziniModBk10; ID tipo: LFX_I_IguzziniModBk10: LFX_I_IguzziniModBk10; Tipo: LFX_I_IguzziniModBk10: LFX_I_IguzziniModBk10
Elettrico - Circuiti - Dati elettrici: 0 V/1-5 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes; Sub Lightsource Visibile: yes
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Quota altimetrica da livello: 2.3 m
Name (LFX_I_IguzziniModBk10:LFX_I_IguzziniModBk10:...) | Contrassegno | Host
8921478 | 5042 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8921510 | 5043 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8921526 | 5044 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8921551 | 5045 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8921616 | 5046 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453682 | 5315 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9453713 | 5316 | <non associato>
9453726 | 5317 | <non associato>
9453739 | 5318 | <non associato>
9453755 | 5319 | <non associato>
9453768 | 5320 | <non associato>
9476235 | 5408 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9476289 | 5409 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9476303 | 5410 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9476315 | 5411 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9476392 | 5412 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt

# IfcLightFixture: LFX_I_IguzziniModBx83:LFX_I_IguzziniModBx83 (5)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniModBx83
Type - Costruzione - CFG_: ---_0001; Mounting Place: Ceiling; Mounting Type: Recessed
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: BX83 : Miniaturised recessed rectangular luminaire with fifteen optical elements with Neutral White LED light sources - fixed Wide Flood optic, DALI. Comprises a (round) optical compartment, frame, glass, outgoing cable and installation accessories to be ordered separately, where necessary. The optical compartment and frame are made of aluminium alloy and subjected to a multi-step pre-treatment process, the main phases of which include degreasing, fluorozirconic coating (a surface protective coat) and sealing (silane-based nanostructured coat). The successive painting phase is completed using primer and liquid acrylic paint, baked at 150°C, guaranteeing excellent resistance to atmospheric agents and UV rays. The glass-holder frame has plastic end caps. Tempered soda-lime closing glass, transparent with black screen-printing on the edge, 3mm thickness, attached to the frame with silicone. Silicone seals are placed between the glass-holder frame and the optical compartment. High-definition optic made of metallic thermoplastic, integrated into the black anti-glare screen towards the rear. Grade 304 stainless steel supporting springs. Equipped with IP68 box housing the control gear with outgoing cables for connection. The optical compartment and control gear are connected through IP68 quick-fit connectors. All external screws are made of A2 stainless steel. BX83.47 - Recessed rectangular ceiling-mounted IP65 luminaire, compact body, Neutral White LEDs, DALI Wide Flood optic. - 31W 3000lm - 4000K - White/Black LC94 - Lamp LED NEUTRAL 4000 K; Modello: BX83; Nome del tipo: LFX_I_IguzziniModBx83; Product group: recessed luminaire; Product Name: Laser Blade InOut recessed; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___bx83/
Type - Dimensioni - Height: 0 m; Length: 0.423 m; Weight: 0 kg; Width: 0.048 m
Type - Elettrico - Number of Poles: 1; Commenti sul wattaggio: 1; Lampada: 1 x LED; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 36.4 W; Voltage: 0 V
Type - Elettrico - Carichi - Power Factor: 1; Carico apparente: 36.4 W
Type - Elettrico - Illuminazione - Luminous efficacy: 62.6374 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 100 100 100 100 76; Color Rendering: 95; Color Temperature: 4000K; Lamp count: 1; Lamp Light Flux: 3000 lm; Lifetime: 100000 h; Socket: socket; System Light Flux: 2280 lm
Type - Generale - OnlyDefault: yes; ModVariant: no; ProductGroupID: 4; ApiVersion: 132383237; ConversionDate: 11/11/2021 5:00:55 PM; ConverterVersion: 2020.2.4.0; RlxChecksum: 10d37ae5b185f1e8ce64e72a24c6d815; RlxData: ZN3q8ryccAAP3mK6ymzIAAAAAAAAjAAAAAAAAAE1e5UUAf7Yb7fCEQFjjkd4QJ1aKGDWGpUsPWGh9Xl8R12QHaDwZtMtB9++hxH5hdB/yUbcVMaWJWLsY/LJ0+F2mUFnyAk5QrSIIzjjLEQEPnebmKqthBOqlBJZ5KskzoYNW98D3hNSny0q9qMNIAyDGDcKOv2hfwwM6SDyUEwtIUJKYGDbl9llCwVep3nm+zD6iju9G6tmPHHtKfSu1m1qwavRWEZBE0S/uXPnOIDGTRRnbqg42pYbNqGuaMpu1ceVN58k8G4YaqnYcLBBB3Jwyvn44V99VpEQfcnW1fTPLfKjD9B75dh4UJJFlzJrIkMUPVytUZVihQlaj4P6FKRk1b+wQtUBr3sZ7xkCWSYVuQO48xIWQ5ze6eD8TMPasPVbVHmTBpaX9ODMlishcka0s/GHsZGFFLYC+3eHeAQv020tqJiKIyMTMQ/ZMOQ9ADKENLhoP2nn375oEra6Xo30VVosGLyC4Im43FCr35wxhZQizeDf6VnKe9Vh4mH7rDh2WLpZfdUwXlAuIFbQUmrX9JlBi/j32jrIekUvVkLeh601rzIN1aNK+NR/l0ZiujfnLud15Zzp7jSI0fSXyEXtzZYKx63eO5jNkmPBqpMfvV7BqEaxGdt9ZV6II3V31n/CRdVY0PvPK8+n0yuGCHxIPeWhCmDC3wICLSyI9xodmEnnhsZbQWkLvVBsmjbhWr6DRL7E+T+aZAUWFOGz09RCwgJkajHStB/jOcbc42qfASti6rq+FwVaQj8wjTsw1WVsxElMq79HG/asATiuWn2v9G+KZsWayI1DiM8jENzSzCCKcc3tWDpfxp3Impn6pLV2cXaipe/92ebi++VglA/d27x98tbFAS6FftFEyNdmQgmUZpA/dVXdIionBAgBtzpNQNBvpn5w9dhVAwzP/wlfsUTboHa4mXXYFuS2bUt6ZuusKmGD2DtBNS2E+JdPCNtzntgFekCYZuM91sneCmsWMccOXyIH063sZNu6dWWJtrYymqXki5f1teWi1B+bSbjAQDQBN+RSowdRuwLy9XukP6tC+0kfhFi30NAZYzY5LL0NdzLFNYsx0HGYRKBPC2JkZORfJowKDETww3kk3osrkAi5v8v9+h8tw4LrCIfVVtBtD9r0VCD1/GmBwqjDPrBN4jxGdZXzL2rSgUXeSAauGNG2Z586D0DNvSJSwsWrCtNW8QOhWgxTLmT8Qf26eTRh19ZXQ4BwlJDEgYnVF/ufID8ZxdVgzO+VpdjSqurpBMLTubkKbNHHIHe7SFzAhab4UriK8lDq96mM5hIA+jB5zDvQlWjB+e6La3eGoWC+0hWf3YuruY4+aqz7DGCq2ymBrG3tAHXKe90YphJaelYPtTEPTebn3h+o3h30A8eLtVoA9Ximfas08gCJ1fZVYqdnpmZ8Vo1SIm1QNLwQXp5zhFFCaS2uz2hdBcV7ApiUH8ESD7kiSMCyWnn1mppx3emsm+f2O8S4FpN6CMueaJK3KcmTqzMLeKncUZJfRpPkdPWutUC67j+InTSVTJ4RHsPN6B3wG8hjQvOXV5c0ka3F3RL0BVGjNbjifr9vmCrsHtMLvxMu+y2ZyFCbydy5r0yQrxB0j1mQQVqKQH0iok1bblPB3ifxSyjY+XihF/+v6T1BIKUm33MRcCtGFvuGFE1BsMdFGOW47qWXxsI7Yf6Bu3KsLCUpa0QUnWWRoapIYfeeqMC446O3U7W5+mgF/z0XsmHszsVcDO6Xq9QP/NI9kG/xEhywO8jjBsXMH37Id1jD0yCsHDudaTOtmHeemhpQnnCyh2ZNTKynaqVWg6JZqWo12CEYFVhjve+AXu93J7PA/4p5lpKBr99m+UByj7Gal4e7fXEE1EauEcVqCPKoxIThStEtZ7N45ncY00QODYPL322u+rCLMoBh8AMpemaWfNUauz85UcNQgIi45d+f67SmOmx0oln2h9MkKGhbo9edgM5fEncaKYkqx6Vq/k+7KsQkYM9m6rK5uDJ5hlV9216hZHyCZ0/sOHX1tYehhg9mwfc8O5PUsVuNIsLASbnGDEnFtetKXkIE3rL72b4370HZFM5AhwjrWb0wcP1tsrbOzXs2ngNtoI57S3SMh10EfM5/Ndoe/sw1IorrYiAf3hKJ5Mima/dVRwwSJbAqtC3Ku8v2wJCW25WD6k+r5fZ87bOvRmYOj/7INQCvGO7991d/eGpcsClrvYkI5enBkYVfsQR4PXI38u2M13yMUS96jFKhCox+cxv0HFKJbgevLTPFGj/J8+BliW5cqZhkkkaoGSasYwTN4XHGFzZ69BEIdEl8M+8knP6LbCVMYQCaBNHNYvJ6pP2BiC3agTztb8bf0AUo5h/aOjgDBOxb96eO4aLo6uKsgD9DziH5fWEwB0zT/NCgycsHLfUcHA3KgC2LeoGuvq7cVIVXYe/chH4NmcNCeLDyeyjLUwMACCGdZdYy3kEnesIJKg7tll6XO0ro1l77vyiHDWcTFT6yfNiroZfxUXJjr5/oIliW4kbc9tMetI/51WWmOczwHEXMqJUDbKS2J2YCm3fyXOpAO3alrSVcmvD/IMe2fMW2W6zcV95LqpvERFn9KrU4mzBYJtWTqKwhJBpXsSfKtAOWVSP0bQIGlM5Y9xJSn/MOWJ/Uata6XbxjvWThoHQv2cMnrAeDRMh9UscmKjz2WjmJ8RVO/f6VGy6EwiQuzDR/j4ezpaKZLGlQ1U4/GxjB9H2XBCZfol2RL7Yy3zZxRxm+TkElvxsYeDd/RJ1NZ8vQq6Jn/Ugn8+dILhtx5DvrdaPCmog9NnHzjbXuoqOLFrdpfpSKi+pkvuOFAFR0BRJdt6lvHQl1P88tu51MxRYII0hhrvlYQot/suSer682Es/CyFAQfDVn3izpQOzIvsIpkn/ahRm+5sXT0ovXE9eWWkziUAqhSyiM5d5iheFQeEvHUCOxOLoZ9iEMu/yzpmpCW+vdOJUfnJDDh6x4EVeP9L/qo3ltPjjcdbuF8VYe79ptANZhCzhSggExtEEubtfCOaGLzIgigORreSM6toxsQlLTcEh/LALepPXDNrijRon7zqxA7LHYlvr2g8xA0ULT3YfpaLRsGDLkepYoIUEO/psBL7zcGiskxsWq0bQ1hq00L7xTHA5WW8IuhMVzCBOZfd3NDgEy1ZNpfw2cefzexVh2oAUrpMxuJ1AI2vvODgS/F2jjJlM/IBG5ZMEv3AzDr17DxRPXBhh3cA59/62nkT1/cNUZ3wN2TROdVcPj6Gg3q8uY41lzuIe2QcbGeZtZEoU+CbxWibjMEXZ6nE15q1lQVeGFRXGcxKT8a3IUGt3OrBPX4ssVNv1pb2/eFu5r/OBg83TqoQx4/9VjO/x8MH0+krmIbnwaXhXY2d06lcutO6+UyMsGl34dJ3FiFTBoguyLWJNJOpnFpKIuAzqYkBjz9DwYYAt0/YX12EvnDselsHZjWQjq8TOIRSXirGEzcn/5hA2/P7AMVZUjjW+QYWC8cpFI1V+J5LTAAxVue0gjttdNgwnLVc3ASPtNzG/9yF6YwmBbYdyBWVnPxrrQPrhUnCOg/0tK2ETDRAKDEHvrc2IGALAE54GrrRHLhut13XMnHZSD6CIWvKn/ZKp+nQF9KcGnB+3qGf8KINNtzopMMGiGj27c+BBpComL3io1aWwtZ4Fq9DrWdok8ajtAAQqh7W7WuIQ7fhev5bsLCVNDrSP/93CMIKsy4DZtQttTjw5HjlyAXYj14dMNUDQREHqmmjKpL/fPqv3Q8V3BHnug8Tns0WwPrHRmsKx8QOlRjSuD9kZCtIaXZFmWFzc0lChIMY492gqlU9XGhG/KFHC2FwvTj2WlknXnZmZGYFDZAi1RVVnoMvxooom8Y/MwhAN2JVBiGHkIlQG4btlkMEOmAMAfypZyP7hwrkpdeocxoyxE+mLoGUo0wXMCtvAcTTQJvLLxYi7KD6syqgUIxPm+O1abGS05/n2yWWEogQtMepq4bccZUIZh2QX9HEWRyIrv4TEXeak534eMI7hhuvG+Ju8/QA2vMlE4yTWq12vhWH2zBYcSE1a9u9hylAr7hj1ZJ8Gw5zJ/rhpVpysB4+4DVPB292gm/QQzs4kDAws4LhHirb37sOPE+ZBL9BAuLTytn5bPHGLzAq49blCbiIBTsP6fZuTjvS5/c/9YArBkjl2MbzqozoKKp8+zaIf/3QuYQBPkq0RJBaMDFfO9kKFZKZkF0kbcIFRkWLD9dCuBMfusjv+pZKeTLNTr9PBBw8mXg2OtxqgtIavFmWdszH3Zs8SrZSOI0OoT1PtXFwdE8sS6BwHswdniWag9JJB2ZmaiZ8QF5HY6TAnY4a6cV9QNEIbPz+YwJhB9LwIqxopxq5zIOXrgJqGLbPbwcYTFN4nc8/w4Z6bsHcP0sWXtsofaOuJ2jiMCaYtCnAaWv+t8rwo0RHLCxCKQ+zrwk1ezLCm2vrWBdSz9zfQOd5JlrgZoc9jrZ9VNsGMLGKwJ2w85u3HXR0kr+mqcfCKZLU9Z3j57EINdvJCZMV583WCIaYmN2rG6OUgtxaD6Urqi+ubImhEmt1EGeH1+qlo5u2w8CG+P9Kt7QHjR1l0+qIUDCLQCKS7tosOHTdf9R9MoLJBn5PxObcQx8HHZi53U9slzv6Y9xWcDSeNE1lbw4Fdu8mKxnrzAbBn35XBnYONyF57lq5kXzHg0/Iw0oGcbqH8xLF6qy4kbEzutOwOLbrid6JlPRpCs5VKF6hBZRyrprptVcMjsb8A6gcUeBqDHXouySXE2bTDfX4e1/J0GNEZPeMgyYr6T1iCTa4ut8rq8U5RHEfYyZlUDL1KV8f0tlDhUfhrGyjFPz4mauQy3mKWlPHRcp+MtfFXVKoVo717HC97ngJW9Czl0JepXQfrdbtJu1aK0/kaXGDsCIDD1oT2+Ncbq+D7i8O1iIGo7zyvqBsyULDlc+q8eWdbuqNy669mHTers1kD6YOpoRLE5zvgSsDpyl2Ieuno6gNm3y7vPh/XoCVzaTDyrAn89ucYvfQlO51Oi/pkiXye9jrb7mLJVJ2pCwUmfwmg7Z2jVHTJiSfCHetZZFf5S7hpjAM4Eg3dod26P0onIV57XojzWZjjrVLfE4nD6LUodnmgZZhhweoG2FWriMd4JKCQy/2Yn85bued/Was0yS9aiUHP1qzGH7OsqisW7gy3/AVmHbx4Yq5rUGGsaxtJTq2TT5xcdSE2y0DIO0dKUDrm8/zhX5FBlN0S5F8Xo53lmy2nZ+P8UAk16UZTyC7EVdjKjZal73/2mPts7MErKbzaEpvBK+Xmub9XmlT3zwGv5P5KYS6qNUVqJhwaoKz0J9jT4Waxov162INfZoubiniUj3OmFFn7iXcBEradGvLplo4pGytDChueJamSmPDKyEC4TnykSpzkSXAMmwCCSmAzgKPDq4lMoPnkwREhQIWfgyoExi6+gSurNSvCGO7eeZgS/qW5y3S48A2CKeTI06wZWKTco43x/u/S/kKFL2gSudq9lkj/Hi57gWWdtFjJV2Mpsa1tVgA5yxTdGLSPNqsLviam/f2TPqCpQOdyTyzLKJsGxTw+h0nn1wSlay4XHOrVwEyEzQEATGmdoJ9zM2v5CS1KyCEwqqBUcKK0T15sTqe9W/Nh7/szVU3t6ARW4//gJD1FYY45IruoMtM4Gt5O5Nsi0DidFmgd4QQ1lO5DHVrEYeJEMFswgX3H4s3LaZqP+eAl6lPOWvRLBNsMXFHGnbYeQQc9OJFqXsd+xqI3EMF7t/UFJyYK7D7SmsB9mB69xZemC1EQXnjbB6+pL2RsbzhDeh7cfPr7DTRWWBP3FvHyjWnTKUueKBqSezsIBq4MxeHa7cIltn1ePFcMyLBPngAwAz9pIr51xkNDqQiSw7232FWqisoCHY864hcylOyg9Hht7EFaUBBGjgNrr8o1DMOK0u+UZWAa4IEGGvumN7LoV7L6pVGTWLcjWPU17nQbTvTfQbQdoi8Q0JMoJ3s8XUtuj3RzTfLUPFnuBu4z1dnyFpPmyua1LKo5nk9/llgSl0xNrJFYfx4rDynbAYowF9am3MLHWiOvFXDAsWVE1Ju2NEmIz8zNs7L9Da0EAe1do8k0S9d0S8KMxZecUhmSUhLzGF4FtM4Ka3gV2ZDJawJ3IsMSQAiDRgDOwgGFepIck31xJHQ/XYFSW5drTIO2KS09EAnXKQxTI7Sbg8GOIuYPqEqzYaoPBuLCpvDS64iw9Lr43UoIbrcr9CeUHMeDPcRZyYAXxNn1Qiu7IU3NUH2FkA6zmGrlI+timjI02ChNOM9tTwn2xbU3jLVmjBJn00k8VK3vZpeqUfzK24rscIv5S+9eAPnFFCrItSzeyZTTXTyMdy2fJ35JawH1KVJKFi5GBOMYzc6ww/9/GTTAycbLM8y+P/x5cT6D1J8EiAvNoRIonSd3lUxSX7WHfea9VtkDXIPemsMJhKA1zg0w3ElVnipA92OnMXeHMWiCyTVkipiFeZ2h+UoI7UBK40QBGw005rcj8IbEjzcrbYv6qQB5UGsb+upTVf/6xO/luzGLWJeGlOMnYk1rprq3PVV1vo+Gs49/0pUWJbgb0nZrovox/rt8BA52C8WbhTYCGIPA6oPeYrJyXO1kxAZgyj/DJvt5ZgnH5+VmYjOer9DzcHme8cp804D2Kllv8kAcjnmMfhNkj4S9MjLUkl9MXbxHBtEvZIpfeNaIBOUlrSl6PCoCPJwC5hAXHVBN4z8eobyPfAq9U1Umuy6jAGw7ndoYxVUSdZ3czMw3ZHCj/FLPuROAHheRsf+nb5q1BsHL0cKmHv+cxSEOajEHznhGawB/w5VATWFe1r3lZJ9LVgdDssCfZSKucqtf7864NyGGsc/4Zo8fO8HM4rXXQb4wqj40p0Bfaw3n36qy/W+L4EQndoZX2My9oqwNgB4BGpSf9nQjV+knMwkXL4oQ0dvlqo7PCr1HxaeUwuIixjhqxSb0/ADytsDZu8v77jhVzUdAAX7AczlHbNlnvzFmlkL/2U4RCq+M0lqNZfMavHFKnTojmlNzc2TVgaaW24BmOYFngPkb9BDzakwKtULVpLP54yVrTpfI+fsDpt2zNqXNKwYJkAxQSWFc1YjHFbKkFvBbROk9UCtj7XyUiXIURdnw62q9GAmGtGsG9hHnMDPbNet8X7ZM5CdBjpne3BebjtXYnX7j+CuoPLPM5AoB4OVJliGf7Tqvq5NBhTdy+lZB1UjW2nkwtoV0e0CoGim4Mt3XZnN7RR7xAcyj4NSia8+2/fhtov1eXGJ+qwKWz+Fio6/9MLLjEHPAE7EVs9mWQctnD39X/2VUeWA0J/AndK95bjWtZqn0sXHutwk6YdxRUqSx3XM08o2aNJWo9MpH6ijKYmsPLb/n6i0Vp76onHNDZHvdw64IrcgA19cX7rQjWN3iRgtFlM3gV91ndT5pSxgA+JzJRAZmUGXQzOh4sWrk1m00Qau7LTxFwHaPsweTM6MJlyuMJ8jvfzoswZ1pl+zhyyUMKDdBzm5XE1ND4E9SomLH9trARnXsKlkY78EMNNlYrcIKskWP88Yo6uhk02dOZBYAvJ6rmxCFFdGJ9kdxE71629/X9rHn15FoXVj74jUyRR+wNzqK5syENutP8+Tmu9KNPIr9s+0FSTGz/u8OqmHBMxB79VdQiIPNpjZsUCdaqwgzr7hFcQb8loA7MqEj5y21UszpLl8+UpxuIQGpptKTOaJmYhzmtgQsKyXk/uuSK7SllUhiaLMWe2k6HBHGgzDQceJLj3+tYmHGw5EwbiX6QMhUvfHA128QpKHodl9PHABrC8KKImIz9CGn6GlFb4FmhPo4CEC7fFtuqc/ijNjpuFpG5v4lLhy9eJv5DZYOsb+NwE/IYuUvzB2nGuOFNTKvKmBb735DpksvjfSgTM1H8GiwDwOamD6Jj0Zav+/LDMePWSp0J3EZbOrsMKEL/Sm9THndBR3HyW3EWGAIdWbJCmTRWO8y0XkEGG8jL8emnf6Whbg6ZGXNXxXpiuLZihbJN0ZoYbFV7PCz44MYMSlrFrPMH6MbCxUSwPpp9jBEYV+d+FFeblXjqLRWjybulDsstuVOyfhPpXOqaI4nQ4JW0htpOc4SBYPCDxO1RMDjvvyCCp6kiqr2ORA36FnrtlDqNdesovTnnru5EE9fmbphXCW0wEF0l6ZlH6wQ/IYfetkEQQ5/bs7qyW0WZMQcOIVrM9wn99e9vvtRTiplndDwdYM7p9cYBGUxFvYmQgZ1yakWnYYdBVk1vUh6Q7Za1JD6+EHgijazTw+8WI+6m+4xpYZL0oldL1Q/V5vudpgs4/6f0R12BaKuNB9oG2Hp5Lz8sff3hR3x/IkitcXcnKNJE7oXGvbqwhjs0BjDL8vITC0jGt4t1RluDfHXKQVbRU8t0HZAtDsFttoxMAXUFoZB/O2C2v6KgCHT9hZ09jlh/srl3d/wHvb0R5Vxoz3qhbF90wy3W0ny6Tk9XjY+vXGUBZmuHUyKOs03wsK0siqLEWT1TGNr1oZzoXB0q4qhvKWghwxBpYlRmzIT9rOi2zf1irt3wgCWWYqnr/I9x3W+WhmEvGKokiWBRjXJ+RYUFm2TR6mYgeG63VprzGl9qxhDpnNblhyoH0p3qIyo9JpMey0lkGcwYN93QUOwG20bbuJ8PXOY/Na7++dZMEJtyIM03EWqcOcvPveqUBON6rpEJaHan/hB1Azkj42ShhPfhVr5TyM6kTV7cqpuSq6748lnhKHpbLAkCz9ljUWpMuH9ThXA2PKN6fSiEqPqMA3yJ8oX7M+tZ0wrT/y4mmpY2fxypyAGk6qdq3Q99g+2jcvD4sE3MYcxlJeaQZLUX6j1t3ZH34MeCq+O8h4BG0tZkTLtyraIwyw/ag3H1A69QbbWMG8yM7PFKE9CqZ3qRLobETLIlZDjev3ZaH7cIfPIMJzAGgC/+Ne9azygIxyeW30zAl4sKB+c+HwpvjE8tZw/sK8mzIbdQa9bjQr80Z67EtTvxxy/kPkQKvvC/S3yrtRXzeyEXa4jnu67AfqFLsVEdlKFPEuwW6ayPAZd12Udf5akW2QKUCpdPXfQ+TIjfEz4fRs1E7gBIv0jkLl0GOmhnLJdLNns0JeOCPFtan5jjv9RFeXBMmMVi4Gj1j08tKwUwhAliH+Z9M1dFfZpi5w5WuembgSCK3uRmSOSIueqcaHD+iAlzC+9957s7Kdecjk5QBSlGRCCbQO279oHFhEcQngQECB5qXwA8oAX1mKe4E47rGkm8MLJ3CzjsWFFzgEuSF5AajDguWieKc06MpM3W8NqQ03lbwsRmR+VkqwYk3ui60/YRjCHrGGz3fDBHYOUBmR6Wq7mZQsEDCp7U3PZ1EvSZLNfMAlYOkvT8UqIyIlK4rOEytOTQS8KLPPFa0qvDo7IryWom6hYTY3i7lbatdow/UlSJBzD4gmPudI4C7eR9GcS9BAVdNfOXiIs9LUrT+jWr+DoBXaRTAjZn06lsqLImefhJczHO2WHNlShMe+YRH/kdeVY2LCe4PljXMaAIC1Pb2CoI/F/sH9wHwe14NZXKZrALLmRR6Zk1tKpggF8OAfgz9knk3bbTmPoGYFmlZ7yvAjR3/Vk1eU4u6L4dGj+wjvk8HuZUj6ZSPgVcp2I5nPbgbIBRcQddNakind7zPHn/jzkGt7wFiZ3KMJfriUrIEVovzC6ulo+iLxCroFxlccdD0l/mPeRi/1eQvz/Y/ObuJHktvnzquUxFSDLefYFAHrELT8ee7lkff2bkQzURinbeoNy92k/hnBYFc8i5ViaiJSbrfSPdtcgrdbZv4EPszPVUNufeJ0/w5AhDnux1Q4+yRw0731ZrppEzv07fLjWLKAYPdacC0wofb2hBkH+DU2pnaVN80B/hh9DraAEeIOOD6DDInmcZJDC/uKxdsq3P8L5dIDQAksG8pd3IEvOocwt8KyN5Jm+1G1lkLWYiVx0swns5Z+TGadJkdlTokdCcnSvZlNh0Sut5Du5Pv2yX1bg8aX3gTIwY3acMgYFOoAcivEDDb3vuKFUqkoLeoeiypteqqQe2gaI90pkmypSGUi1fnhZFT3JzH0NI6A7griE3d55sWvN7g2RiZlOeVRbNtwZvddHmm6d75AjptcAt6I9yfrQhXmIcy2B21iScc7UTaY3hxDTGDZ95P4HYB7fuZchZ5Tg2rkeiqBv7zurQG14Vq7hAbdyPJqzfHYddh4NreG1v3lOCWMlMPwp74YSbAHue0CR2TVQNj5UTjYqpY0R4D6jKNqUBgK01VXWnszxi2svvOJhODaC3Cwyn+HYC1d9gyI5AlGGy2b2jCjv3pRkHT8YcscHfLDlGdXBTe753hVNCnLW/BmR9wSx1VxmgnlRBmnkGj9pIji6Z2G+ptrJm9l+YG22VpZIKAzuHu05s9AQsZc4LDDHyI0MwRz7MDfLbYjt+InU+wVxLC1ASqCMUkiKkAAGq5lsmBlZ7/XJK/chptdHX1xiaJq8OOoif5pBm8Aam/AZ3XbPDjduI2enPzDhLpKPBLF8enLdz+4xOdo92C4G2q8eqrmvp0jJORhf4cdmP8NgIVtLdPIYYABiQ7/HqC2Uoo8qZsRUcn6B9grr3lENCRxOHY3NKR1PiLedXMuGVpw4kDoAzQgbebMf5Bzf6vhr5cNGkeMaNWYyy59UpW9Zo74eE2SJsEOYR764bzKN/LPjqBNIfdlOHYMv1A87dC1aNinoK2W0wpvTH5Tk4BB0jV6Zy3TdIanbcqsIGIkz1eOSlOC10KZyBguZHXXjct1MuUoVea5+I7WBNBhaRxoQrnHRzCn1GTw8RHIAynpnj3BzQmGPDSE2kc/V2u8HJuxkhz+HFgINSY3cOsauKQSd8XKsGQLPrXREPF33yOTvLmdU3yCzUICSe5qu5nBF9avutjW6sv00OwiPpiYf/dNDVtuY1xs2kLlWhI2yNuju5W38zc1wVpTre0OJDBinB595AHN4HdOS5V03SEml8pn8QtBj/Aw2UfEkWcC2bRZB0VkaeVJhAfwLOK1sL5rJWkiAq0Xh2vXgf5mKCwUHxrqy+jlRN+Yaci6HDc59Qo6Im8o7jOcIh2WY+edXnsN3ZEGyqa8whRUhREwZjZweMAPbyOsNGJMyYvhesEmM8wTa//vyglhwTTmOUfoEIMMELbf8RYE9zdo3xCCYyyJVYR3D7MtInTPIfnm8lL6SKQXG3v82KRoocnSdJZ6+SakTClfkAjBaO+NAblZoVQ12jnkE5XAHiWWTpoejClieVya1SncgUSbz7jyMX4q3NSxX7v6L5kJNAE01u86jNVhcQuZPOGEz+dvRMgyEwLMuPukSwrxEEU+2lrYeAMbcbSJmF3BajeV27pH7pom7wNRTpifyrycMKlePanuCJApGCoE9uKV1CndvvTNepRyiNzvjY9H8wv1/2p/Y84b/keSCP4+jo/hJmNV7AB/3M/HGiJphOq6fJADAxyR1HehzC1Bo1Im9nvMrEa2LetJVTN+syI/ntdVm6+qi2uaTmMIrt+c756L09cc2FoiM6oXJSLBs6GMOXFaxj/IwPiTz/+p/0jrtDLPaJsuO87ivSZNk+REWnxFuLFvRXSFzJoDJFUgsePgpejfrhPVxqoFjUdsnMaY74JnQtDPNmVygIHz1zoujodfExkSvaRYx617AvUD+j2fV9FJfBZUg7UCQPjUPq6iCjosDF6Vt7qbXib52E2k70VCs3nOdhoEytM/dif/60lfg7WIY9swr6/LaAGGD8AALD2to4Po2niF/upKAFnfAWnUpwYBse84s3S2H7ZtbFdaHJyjSsf8MkYlUtc9VtTh8H+SO0jfiKuA6gDFsocRYCLYyDPB8saj2Y2UUWIDAgtNh92Tx/EK0upre7RulGl5Fn7W7w3PN98lSfobmbjDFA5CIz8RAra0Hv4Rh27KPKaMdtUuUqA3yy+UkH0sAXRpOyrKeYUYxzGSUn2THXztWurlc/A6Nfrlh9u3f+3AEhcGUzk58/F1fWXBumIq/k9WUWiZDXMelt4g6ypYI2Cqhntsq39gxXWwRO5JgGpWYB1AuFcnTtmPYgektmDgL+QVKm3zcVhOsGb48iOM39B+Pz2q+I+27AcvhaN7nGEeABBd+K2bLQGwM5ymXvcNSvSbhqPJRd2iEd0tspbpALllutR5PaHBhd79A6kGIREXEGJ7S/6K1y52qFPcF6+y5RitL3vAA3tb2++wm8y2t71b9/yKRGaKwkRCMe98lRDntIoXhSYoCbaSjtllLB5uLB/bD7l/jCpIWBJg0OMhlUZydQNj+4y7iwYF4w/4+HBCl4GySZRCei/mAlwRXn3urKgrvSAH83V2gZAb4LRrIWX8OI2E5no+pdRizLPptggO4888PAuNuAiGSk11es7+FDgG6mz2BC+DFFQkWVAbpYiFqwq1PSvQXAi4TusRJaCqKhVPmzY6QcFpUFPPnEWpSnpBKNfa6uDVEYshzc6y62FHxSBOTaGwpAeVllhpCtwGT82f/1mNwBJmv41bKkOzesE8DVKJCr/3xS0YVXEjlJmCKZGloKH/6ppJ5hqxJeZ85EPtaDQTigvDna8WNlsVT5sLOYTvqgi7ZO1bJGir/uDqX+oSqwBkWgfImQO94Ngxh90ON1GeE7qr8I7DX6l1y1RDIR/DUUCWOa8rLI+VB54lS0mWkjrylsyKbbP9QJhi11mCRRCobEdKVXSL6OUdx7FzMzJaDAd71l7zbOc/4Xn+Uwz3Q7KKsndLFLkKxDXcISY8q8bfK6hcFW95Ps9lYaXozeR72ccrv6MujctTEGhujf7PuqGoC9LAFeYB0ocB5TNu3a7V2RKf+nDyGxEgB1fful7D0bICgYB8IbwObkxD5gU49a+IHHAjfI3WrX1ReDYXRDoN/HFbrs9bBqHh7izmXYYufTM4nEbl58Ey5+WMebGUnJcOTLqVHaSJh4mTdiqfadZW6ejlbWZSB5/fWbXHAIU8l3F6Tm/yA27P7LVdgyDkbBol0WEpSHTO1rftoCb/6qFAT05Dc2ESMYBmJgZAkUhQ8iNCAbVnDI3rWdHCp6hOAknrXEHWeKu367hJGTec1fcgmXOO1QndhCT/OneGQwkgGEET1mu+biEjq7CyJUzvTwoRbYWpvTYLNSPeLSV+okw+qWiWXIqgwGlS5ezl91kYb9OckAXsGZbb4kHDqT0wRZrkHbhRf767y9FuAmADffRjZ9shS/Nar8vt/hFANNSazNOVayN4JrMC18VPTz2gZXxrQ/PNAcIOrWtRTyWV/B7fNfey0TWBQDGkiExi+ZOIzRj5GUC60YZnYCTmQ1nKBzNn8Rmn3vHaIbwE80NfIqYRNFoOB2sRkvmN85yg66aoYFCw9iEdOoTnoSGblaNiWF6rsZwi82lVwxVvrwJZKvXY6Hev8VD9Q8HAc+d6azYDT2Ek/ZMmiptUsxP3dbdSzOOmjN0MmZAkRxZYq7MAao+3VzGWi5rG4Tlv3OfzLfFEeSpUYBmDb1Nu29gRTLlKyhHAzsViNZ/vcKB01OneTq6Pjc7PkI0oQGp+cKfAQ4hZ1Yd8SlwTQFXDKTZPQ9tViQfe0LYYDvZIw7JGvJ9OjCO5FJqaUiCIJ9NJZMkCbdIbBERg8OAiooJxZFg0T9VveGvg/dhVEPmGJdnmvzT38WDogeaNegiu95Iv7wz1iZ7dcnjTx1i0oO0mvXAtptNJISU2gwln6bpCLf/FCKwlBVqnMQkGgeBHq+kVEX7kpYEmC+DHSeQ+oRH2tGWEi8G1doc0mvvrFr1+QB2jcZrVs/ivm8zyGYwKd6yhsDMHKbO4P72R35jTe+jX3yXcLG3yMQv6URd4i1Ptc055H8r6M7gbuHx4NkCpJxXuiJkxfzR10Mkt2E5RNSqg2WYkfvkVEqgGy+ON+5cKyMGQUupc/dL92h0HYwUMCySCLDcQNWyB/ZPjsPkSJdVfYIduMb6LCwxctXsnot9H8LWXbbDjboz18WXhNyn3Y9m1wwi0cwMNGiFQIK2IVXRqSHSsxRlRd4ax/U+jEndKSKFNRlAl0wWnu28WAc70tf1v64Gh+TBnE7rAWyQj2ZZr0za5OcUClucjK47FvH54KC6YbNLtrlWP8gWJ02LpLe3xcK9voupZEHMg/KZ6LZsjkdHFIOYwTLUWpcrp2NtFY+h9KVD8478mUWGziW5IXSGCVyOfZkTWqLHqrFm1Cu+PF6Pv9iFf7NoqTceb+0tF8UBhsuI2Q/nf/g/R/3AiEOPi4rnULuLJsshOA+F1UCNE7KWWQW+F1Y45QTvLdJSpXToF1qw7i6XuhOYl1GznXmyU+PINjWD4+izzEFJA7/jgHCL9u1lwCGeBBfnFsFISMZfg1s1IQJl88PWHbaRDspux8nWCg/J+Ci16H9YNa1ONXwaYULx7vievsqcP7rdHXOO8orL/Af5Muw8wcVmW+mjztaCJOHmlNYOgEO2QPxR7WipX45UkmP1bOq9zGl0TJywykKS09w28hH7YVLoEC4zibO/6oVVn5oiVCbYmo1Ovth2qLtukqsDU8zjypqqYcwUgxon8HQxWO42p/cWbnFpH1rxU0H/9pbX5DcRyEpt5ECGn7wQxVdX7jmHPyQ6KYJHmxbas+UivM8SXHXMPgIJBCBY7PUn9OKo9g6Gzo97H7nl2M+IVKhkZsdT/Cv93wRXxesySdDrgf/28u0lKA1N7OiOncZ7O/LVxthgdfOntEa/EAl4PtcsPlKt8pX3jxL+aGxp6sKn4/uCZF7Er5yjyDO2/COpFByEFR2Ymy1tIoH+Y3pv0bHJ9DjQtZIIfYYFXURfl2S4v7mDdhUPT7KqAUU3CUBKKbul8Ntv0Ynsywddbxrb14h9Wj3znvSoL9dUcE0r5RqwgNFYJtaI69ZpAOan/v9867F3MH3xNGI58I7rn7Ub+E7f0qnF/0+G3VBsxQWxqftbOY3zgHSld0Wke7OVCUmkO1gcrszMz3wfVd7N2bP1/g/OW99Wjaopv91aJHvfAkLJhFoW/m8NW6NnYz5XuW4gvV8ioqkPvU7PBGThOepWwKN1exgs0v1jFtnopzJkpv+EDVKNR8AHTzng4fW1f7CIowmfSV2chriZWt22IxdaGtl+E0caoL6qkYuwhayD7uV19oXF2RYX3KLOaKkzJqbjRIN7/f77ZyBML+H4d+/MV8KcoWRo0BzDXHjwyYVFg5Aa6pn+UjT91S3EXfDZurI8VZUN8NQB+284xaJnGtkANal2szIjd3rk5Foa2U3RkCoALQoFeYI9jyHfjBFOTstRXapGnDXp4m/HURKm8kJqwNZR6Nft/m07kRYo85rkEYChAQ9xeY/CygR+r0lt1zYFD1C9APkJBf3gSHQWUgkHl4oKZxNNrQ6iga6rCp5C7Sqf1d30+4ys9ioRVJEhvgRgYL8pwaa/E+G4UukESwrRKyeVOloCBXHCZMkxWPNP8MBT4EYLjSocrkABYZPXy1irLULFLnA63NM204QxocecUC7FC9rDXV8LjtcvSGKBh1o+QZtaNxjMy/p6fHiL8cwidl01NFSqxucYOVvAsDoPDEWDUSoERvmFCvYlKwU3p+ej/tW8hPscZF0uc+Hi1nKcOdRsNOFw1JDzIgD+7lSHv6vqzPUGGKynk1RMMRhDeBFcOMOtaY6lzeYaBSs8CbUSa3+ekiguOSehd+hWmFQk6hHWOUhbw+puHY41Nke1f5v1Fg36xzq6uphHYP4Jn/oJUZFQGKiEjS7TAgwPxM09uVvf5dlKxDzKJc0xp9HdjUZz+7ISzIPmH2+Sd4p4dUbMsgTQY0eRwecTpwgZjL0+wICNDBpi0i5dKXpkdP2ATnIhQCc9n/4o/ojaK9bZmh1nyBX3jmgFf20lE6lRvSWIxTW4bxCPIfRYooOcTcrh0tsk4pzaUZ5s/BYvCkuPlW3NABr6Geg7jk559/4Vhs1vTSCZHBp44Az8VzMYoRIPF5/bkDJ+FqfUhxEUdDMozC4yef3fGpEdludPWEWNjcyK5JZCDpaJpmEGmMIW+5c50tI8CbIujWzeMaY55eOiys0nMnDsC4ynSqlycmVIdtFGRILuxG9Qe55iPGNEL/QSIHen5blYWb92smj1jTHrxHGo8QurZmKGEpVSaziMfS9i8m04qrUsya9P89vx1aa9u7mbCoy6SQ+lz0w6rhwKYSoj6JYmq4pRkvcyBRL3p1JefD1MW3BOfkmmYbfuRlfuf3oB2RcmBbKSzNO5moGBWxC4IQ6Hy/YdREU/8MGyQpQlvSHQIuMxWWZNrxV7apEC2B53UjaH+0nd+sAry9BWBgVQ4j6LWFdSH3NjaGTiT7vltpYTymI/TlZwWAfudeGT4kCXo6bnpiDdrG6XquJAZde5+PNFv4NVMddZLTGFGWPV9XuZerENKqPzLB6m9aocb6X88owrkkvQZTEpwr7LPv607J8v6WkEGrTu6ASy1hcEYDmPSHhRq4gpvuPn/zx9pvp98fwlXCfzmoDkBsdXDK2NwAGZceg7va06k2Tc8gx374pb4pG1fARKyQ3kZxIusAsbDtiBLDg+EujgBfd7EfLk4RltgXWK4GZJp86TijP63QHfoXIo9ywJuPsq05Md78rl+UzeVUuJ9p/PYAlPNPQxeECDByuhZXVgFLIL6CRA37R0jMB3ZPKwqoi6iLtxnSSychtJ1TiUzMUBfmR2Rwvmziv8zG9gUxO3XLhnWc/4m/6qXWo+A1JEkZ+ATwXvUu+z8w5ift0vkDPUKiSeLwk+VyDJQWoFyOlrrmRS/Ic+DgYw51OhzgwyzaepxXKf2KZ/0ulSQ8a01J+SKsuQqB0Fdht+v6tE+mg7xhlKsuiQwrwsAO+g7fh//MYYWnMKDmWgFglz34791gmz2lljiR1hp5W4fBe9Atv/yzlA00SnT29bOYGRrfNHmDlFIziOL2Ld+l/H3vJ/Ac4pS0hy6rfwgmydmPB2EucYQ00AAIEzB64P10vyRpZsKR9IK0EyaMbAStQjOvZkyXCAdW+1GA8ZY8IyK0GVspPsq5C1mDBcPLyXGzeMYFiRRp/9Q+9CILwJuCKZlOnJ9nASNvlYvqIMV209oDrl/X+EmSjuD4WQ/wYekbZpWtbA3NnTK2Ew3rwo0Jl26MXN3Sjt5ShzIyr5LnxOfvYAP0LxCKUH5QrWyw+12ThaAXiJIPIrY9vUZGfl2N6rY/tG2/rFZymxKUP6+ET14unomoyHrzD+7nvfbKE24S+x1x/VX9MDKJxiYoHGOG3CBEG6/Fy0Wa+J0MYkFwaxtgEJgOUABwsBAAEjAwEBBV0AEAAADIFtCgHs6cTPAAA=; VarID: ---
Type - Grafica - SymbolApiHeight: 0 m; SymbolScale: 1; SymbolApiLength: 0.00423 m; SymbolApiWidth: 0.00048 m; SymbolHeight: 0.0008 m; SymbolLength: 0.00423 m; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniModBx83
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniModBx83; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Altro - Famiglia: LFX_I_IguzziniModBx83: LFX_I_IguzziniModBx83; Famiglia e tipo: LFX_I_IguzziniModBx83: LFX_I_IguzziniModBx83; ID tipo: LFX_I_IguzziniModBx83: LFX_I_IguzziniModBx83; Tipo: LFX_I_IguzziniModBx83: LFX_I_IguzziniModBx83
Elettrico - Circuiti - Dati elettrici: 0 V/1-36 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 4.4 m
Name (LFX_I_IguzziniModBx83:LFX_I_IguzziniModBx83:...) | Contrassegno
8687309 | 4180
8687351 | 4182
8687383 | 4183
8687394 | 4184
8687405 | 4185

# IfcLightFixture: LFX_I_IguzziniModE884:LFX_I_IguzziniModE884 (14)
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniModE884
Type - Costruzione - CFG_: ---_0001; Mounting Place: Ceiling; Mounting Type: Surface mounted
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: E884 : Five optic element, outdoor rectangular, ceiling-mounted luminaire with Neutral White LED lamps and a fixed Wide Flood optic. Consists of an optical assembly (rectangular), an upper base, a glass cover, and a ceiling plate. The optical assembly and upper base are made of aluminium alloy and are subjected to a multi-step, pre-treatment process, in which the main phases are degreasing, fluorozirconation (a protective surface film) and sealing (with a nano-structured silane layer). The following painting stage consists of a primer and a liquid acrylic paint, cured at 150°C, with a high level of weather and UV ray resistance. AISI 304 stainless steel ceiling fixing plate. The tempered sodium-calcium sealing glass is transparent, with black serigraphy on the edge, 3mm thick and joined to the optical assembly with silicone. There are silicone seals between the upper base and the optical assembly too. Metallised, thermoplastic, high definition optic, integrated in a rear position in the black, anti-glare screen. Single cable entrance via black polyamide PG11 cable clamp, suitable for ø 6.5÷11mm cables. Connection with three fast-coupling terminals. Possibility to use unipolar cables with 2.4÷3.4mm diameter ( 1-2,5mm²) All external screws used are made of A2 stainless steel. E884.47 - Ceiling-mounted Laser Blade InOut, Neutral White LED, Wide Flood optic - 10W 1000lm - 4000K - White/Black A76Q - Lamp LED Neutral White CRI>90; Modello: E884; Nome del tipo: LFX_I_IguzziniModE884; Product group: ceiling mounted luminaire; Product Name: Laser Blade InOut ceiling; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___e884/
Type - Dimensioni - Height: 0.102 m; Length: 0.158 m; Weight: 0 kg; Width: 0.066 m
Type - Elettrico - Number of Poles: 1; Lampada: 1 x LED; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 12.4 W; Voltage: 0 V
Type - Elettrico - Carichi - Power Factor: 1; Carico apparente: 12.4 W
Type - Elettrico - Illuminazione - Luminous efficacy: 61.2903 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 100 100 100 100 76; Color Rendering: 95; Color Temperature: 4000K; Lamp count: 1; Lamp Light Flux: 1000 lm; Lifetime: 100000 h; Socket: socket; System Light Flux: 760 lm
Type - Generale - OnlyDefault: yes; ModVariant: no; ProductGroupID: 3; ApiVersion: 132383237; ConversionDate: 11/11/2021 5:37:57 PM; ConverterVersion: 2020.2.4.0; RlxChecksum: 354d6be5f80d61cea9115ab5d56650e3; RlxData: ZN3q8ryccAANfakr9gCEAAAAAAAAjAAAAAAAAAGMNKMoAf7Yb7fCEQFjjkd4QJ1aKGDWGpUsPWGh9Xl8R12QHaDwZtMtB9++hxH5hdB/yUbcVMaWJWLsY/LJ0+F2mUFnyAk5QrSIIzjjLEQEPnebmKqthBOqlBJZ5KskzoYNW98D3hNSny0q9qMNIAyDGDcKNyAiQ+63AATEYp+8W94WjbHuBDJmUrsm/8nbWdXBQqwEc6Ucluib9bM2jNUT7CHTP/T6SKab/y4ilmPbqANF01n5z0Pmv6N3ubB2tfOcPARUbQrJAsFTFQw+SHGSCqZLVaEXAhIp95utVWV23PHWX4jrgFJbRpXWRW5c4dRw3pcoAfK8GwbQC7qUw8m2nrX2J3vVOtHdK/KZfjkEOl0n8jdjwn4PtB24H6eRpRadI1k8TtMChrytHVTqrOUmwF1ftFbW3xHomZo+TFmEXXjmdg2+WBFSi/24dHF0OiGoRoiazFxXBBEoAnF4WDJe2K/KPZYb2qIdxOlyCv8biFKRidBxb03ovfDKCcmDdXrgmZywdjJ+yZMjVCf75HOUCTHbQ0wFvXgC0kAnAz1Z7Wu3Ll8XeaucqHLSenUaAbJiEScwIuRn66YxAJ1SL5USW+Oh7RJU9t/YzeCZyXHoGC/98IAZ5XNFxzKH39v8CxY42h7d1GoZXvQroijERRNVbIsjWylrlu3zbQnwDsOyiMzxSbaQgkdUb0yCplx4jCh42Qhy4OIi2PBxs8rUEuGIl0JUJ3ELEInwdrJedmVyoOkdcrmW+o8xGx9hHoTu8VPKuDUrIQ9JtYiHFjzxaTVqrE4XV7emRApQ1n+QKw1I+g/ixMXPReS/S/JFk2GDKCwjV92NENQ4KDI8Sh7TKmBr9Y2cnjBZ7z6yLgA16+XHsR85MXRPpJcOSqE2j4QRJiFdvlbeMj9gUsBhO+fOCCI01bLZW60ce4RCH28tPMKNjOo1MzpZ/xtUHl/ZLny8MOufMh0ChhUiT+2ALoNJkl1KzITrnfDOy8c153mQfT5VZ6YnvXpYYUqetxJBHim3HQ1aPVwnuzTrY7figKKi7JD0/EczLmEkYXz5QXlCVSEuxPe5/42zfh2t4r/v7nEStlcRTNZ9n6ikkMObwEp+b9MUJYLdmza0bMNMTRaNzeXQmWr1fNI4Ih2ApFu3p8aHWcxXYi4zsR6Uy6bMUhTp6U3emkxQ9/crWkJo8F0A4xjUVxRBGN726axpulxAf75di2O0ZqEQGmbP2yfVMFeowlEjRHGyKVo1n2IHZNYUk61lDxAe++AWD0cBUVMMbHINcSULbzeuHHPYbjFWo5xea0wr+TIzrskzAsrBiVJE+1apzM9oFNxBQ5AXgixCM3UBY19SyZsYybio6USWJSlLCn4K7iQOtP2qvvzAhmnNies5yAQU67jEYLn8/FVt1AjYxIGVomV5+W1RVmOcE1x7swrdmAmekpcrA/OwM1zLdUYtYYab4a4d2bNKUEn3jIeFW8joCN9Qd50Bj0vPQkQ4vQXFFc20oj2sYNaMs1WpBa+T97UMjqqh0X1rb3eyaEMAMjv57Ob4NAOp6VJPB+oCF9SSraOlmhbto5MA+s+zBOQlRd3pbOvplM8kCsY3+ofIkqm2fqBR5CU5pkjEuPw9dHWmSCjmxR29LYET6hziJXLe9tcRF89ULKgS8X4G4L37tThYPnbBfUIu17rb3ArdgUo6lvZnCDTSrkTtWHJKVyY3shAKfwFJLSajGGmSNAJr7yOzB+mLvvQp4kFFajVfjD3MaikLOL/5FFAgLJegaOvMgaSlP2FWkNOjUZo3IFpRJU5d24SObcI7nJFPKlZwgVtTkU8eDY4nXVbtzpdok3LoBVj5SKrXy4NXa8PHnrAXN6O8PmkL++5ImXqNsx3uNF89JxgAAx474G8egyHTKLFmW/DowwrgwnnQgoH85RrJlHs6/0XnAvhJ3btSWyKcI4eTuJhZNxk9kw8dy1RCXfud0oE30ab9YgInHPRXZhbnQypGqkm0wjIf4g/A2p3VzjupHZHRFMsunjx/BORbNWJxEoqpqPCfWrNfnx+HqS7X8geWEN1bimOe7cwAoQdRzgMKRGV6wth3pjRM40O79K7pDP5TJaMac/eS1x/Mg6OxzdpU00sNOsNhUhmy3vcH6NV6ANOc4KHA/B4UVVUZSWdSs4iU2q2ROlSbMEI/tRbqelHU5uR/SMcV4xDdrxO3pSoCK1mbSWHgQFEK+/IzMHF673irSj9Wks2zBq2laWNuTAdXgXpr8MHjzZowghILerupw7ui8Z1FzrVv8RnCC9erA9JwE2fqh5YcBcAmmsXp9vnY6FfRtyTTxSlsa0xz+SE5xlWZ6q9P1S9Vfnhl+k9nl9QE2EBz8hZio1LD3Hv6M+y8mx0SxOip5km8wP9q4VFL1xr3BjI4mKENjf8QNX9CO1vUmhkZUprQEkhScxNFOlQbtCz+nyhgj7Dhrsx1ZpmJKJW3AT8aUKzAwggw/t8tS6nylszyJoTc0hScxbnmyjaTW4eX6rGeAsIKN3weXF/IP8VySdQVXwoTygiAaeqQ4FfYbXztdC0IxBSFUzfynLziW7wWQyrTGBkwTzjufS7HilHhfWkpsXCYZOEPf56aFXF1NUBXhbvLCoswMbj3T0EXmBleHcvi2q7fb9CwP2e5tzF/jtHF+mS8tbNg39g3IRVq9UWTuMZrTO+hckwT+MjPeqH1+KDjHmSAO2IH3rbWwhEvadpDiyZyjM4j5TTuhcU2YT9Quudi60YUyHhIF+ruUZdReTQ2Kvx6SDdd9MIf6rtg2gbIdq/PSSCi6BCcOuZGkxZFrN/eIIlCFJXjiaoeU8yGYNA3ya7m3QPpdBNH3hYUSuzyrQWo4mHRyF0SJVerUCH0Pb6MVxbsv7f/HFGFAaVkWRIZgS2ImAj1W+XamUdHlFqyBtAGudyo0ksOQ36ZrWDLChb6OQLFOqukr/CgOQCeEnM+ECwQ8Hg9W25c+YpvIfyJS3dCZOo9lADY6lSvUUw7l8m2NazEMt+zrpanfgb7XbgAbeoS/dpc9zTSey8yHnoreIClB4q1la0we8JtGK3IlhIzYD3ewnhTJuDl48NAxWAtqIdl6dlg6CZUGKPj/CA1+ax5LRP5p9+Mrwm2hTX36ppO9/vUvDh9zNWRLm/nx62DbtPdSGj2P/T6HnKth+IsgLZCRR0+wjPegPOTN0BSQ6QM6UsdG8q26APu9HiZvVzF3CojUy8m3067Gebtm15Qb9QMW9Ma+NQcMpH4mzAgL3WiB4RzruGzpn7b3OnZ0mxRSKAJf1mE3W4NuZcq65p92Q+ceDL25E2UWTeP6Sax/FhLP8SRA9oQQSVM3DMfvRESdzDhHNH+PPdGTrxD8UmWFSE0W6Awo5vz/hc9mH/UX5bwmBJpcSsDjEoPaRhMP60YjU9xW9/lOvEr+2KX3tSwJwWYJDEClk8fG8b+KySIJ7OoLnFMO0xYNUzTle9aJgquLDBux2bXD8pLe7c84/wB6jK2MTp0RMrhxW1hCFoC2TbVH3xcO6Zg0LF/p046iJ17Sv8/ys1fp9DobkJ4bFEBrtyXi6AtgkJoCMJVpX0HkkQsJ9JFW87LnSda6kvjb6z7GkO/CRUp1t8vk9/jnbpYdYfeXmqJGL5Kxhxn1byJKOKKpRoc+1yNEUqkvGmhmZZ2WRhgtzjAWl9FTSRUjdu0NLWz51ZhUVep2nyswl9dtvmP7lzwQmZYTPDC49y3NomAFnqBR0rZjwRYUfyet1EHXClXzoU3dKBvUNtgMOWZhkWvkZVooYU9UCQ5CeANKzkqdyMSQH/FPipH3p1XSRGWeIan2h542DZfW8CTNsAQjz2CzclkmkIg1S8r23nkxaRXacUkQo3XvejEkdtmmkQMlCmKU7yM267CUw+3WUmxd0DP4gF8Zwq6d/Z9PDPvp75nCD2kCO7R/N8EoNepWu9OPhNDZLOUxn5e/8EPfgI1H3B74Xzq8Z26o0A8FWEy7wULf4GLchBpv6823hqYCE3KDpdFOHgjW2xlVE3M6eGEhj66eRRSJMI5+0N2FiYX7S2sNA0jzsUBXwwo57zBAQfcbz16MPP0Ho6vKbgZQaZW9qAPCBBHJlCfGq/7PWeI3leud1gdYL1zQ5RwFkjABO0vefiYJVTM6+XYtidPVBB8fO6x6hBUoCUxW1JNWlIrYxTDgmf+msJZa4hbPvBChdELurkHRg0+zRlzSCjRmrE4oJSZ2LbhHzwdLxC8LNTyBufsQq3xc/oG2HaCi4xFGqkwjDkm4/MQ4B4qTF7MGhrKTXdfcscpXnssEly6Ca3TGeG8dt77rsF01OoWch1Cw9EumEfbquiQ6tVJWH8f2SGGfeybK9I3Y13KVQrf1A4s4bHYBVqEyHHzNPjpTy8wVraSJR1neo8AHMBqSS1gEeGRrTEhGUsJMbUbrnitIRLqaDvLSt7QXbLRaiTkRGC1oHuuO9UfRyim+tjb2pmlzMU/9aVgfDCKLIVJsSfqjiGqGnCyNeenVOsDogju99oUixSa4ssw1YvWkVKZx1WcyRlZKUlruXOeCPB3c1wyZm+8ydietmXUn2FhMbdyF0EKgUTYeEQp37oOuxmhj60kxm6QomvIrMAY00nsAYmJZ2F+RX4qPsJrBmryaYbxVAr8dIzM5RgVLomRIMq8fM1PB4gevjE+EQl8piXZZ0fg46dZgrgDoZk420oQ+1LZGUsC4K6hgc62vlWUVnHVbvvwGdrwLo3thx5tIoLf60ok0Wd/xM+Mxo+uIhG+dFq0iOIRUoUP3zrWzpHPnr6mvaYvIklFoGpqj+ZzxvFWRl6U44wY7H7qNB0dQYx4xYys3v2RrZFhlClggxVGI86TDfw801g+BDjGDEigp7RJapuYd4I+GfQm8kSQcRAuPEJpGC6Tbm8v/PGHQCr8qNAXEt8rOHh6EgU4w8Zx943xo3+UVp2Tjt8KMqMh4epFly25l5swJ0OtzsNLGNDqTBjUjPBU26l+8YAl17uZGXPeFN+9GWrQJtMOOsMqjdQmzXIoUiCv6XrNDzDAMfydtVcYQHuiLqGC8TCO5SnP6JsPqAKE3KOfiKftFd6Nwf6xhTYv1njxXcYb7oTjMCpSFJDV2X5GsX9KaR6r/MWFqkCyeHthhaHXrolORNk5fKn5YMzvIov8kFNLksJT/EbpmiwykuqdDslZ+J6T+6DcT/RPjoRy0+wlX68f7Fb0idrXE9X3cvLha1wEWlfcoB7X+mTPGRj845pOAJYrq6GE9gVk95goJt5H68PBTtrziofrew8d5GmJsPgaMWJwsJhHSIGqJGDpc+/AxCSIcEfcNp7yN9O+TvDZmJqg8xawkfAsopupEPhOiNUD7HXgarPHlDE+6Lii3mxi5R6WiM2pFw77wjiwaW+idHLo3R8swJjuXIaBJ+8PkxlZ6/3kHyO9JpP5BBi+KSFwtA8i2qlC9G+vffDBUqSP2TbOCPRxtkyCnc+5JLJaPpAiW1awhYxkGXG1E39laLjVRuqa1bE3pcpwhFTbUAjGUMjR/DC9QC+P/r2WQcENcWxW1OVHOTeYM311v0ApasuNrW3x2qLHwfBbGYBkvdxOMjxnMrUGYN2plrUAm86WvViIZPZN7/Z1T8ZJfp4feUvPYLg3LpPK9S4wVf3vHadHfi9InBToccOmyzF5FNCTS7Md0msH2XqBgt88HAA0JpITky/uqtYgZ5iACs5dyokB4pJe4ZfXPFoy9Bb4916SWQch9L+X1l+TGpz6DIn/56le/EKYdoS0kldIPswpMRM42FB91u784SXvpEwDzCjrgUiGaxp0Z/uPWVdoCZRBJT1KCj9EZn6MPsrZv+8Jz/loc6DiRp95rWQYCgEzn7nlxE8rbwVSXlkuLIxlgjt03hLjmrsfi3+P0GF4dsy3VlWgdT5ieNC1HR3Q1I89GfWH/XvDvgrY1+VL2LwhYWGfJ5R5blGrnRfxmRfb4VhluFCGvHAqKRMlyg6qyMs2TFasj1sk7tP7rC3BdPuhFwHvj16+SZwuJxd/E/YzFYu3SEp1Sbt8SK8gVYpPkh/RZRJ5hB1XTXdDnPtBXs2sLyuQZ9BksUKzi4yPra2NaYukByOj7zm8p5wfJh//+vUeY3TNYvtMLBHfoVlua9g3NThJ0tSlpn2GO5BYenTo/ZQaB1MSph2CK0yz+Sf2BCaIyVBeC1yfyHXeb2h/UIJVOBssVWSbxGhFih8Lh++Di502+6Y+OWifZEYZnBmVPwZZECKJI24lYM9g/1S2C9sfuNFqnO9AySl6fwNwyzdVXyMojUVyyJKfoVCDdz19bBm7wXQl3Z6y/8YpfVPuBj93UjW8RtryJ2GrwJUDSPOYF82/gbVdaDSot1JxlHZQGi7zbIxesx4zieO9RzsUW434lOLu6JFR8it9VSbA8h1kA/1XGlWdLkMczJhvbY0C4S+At6gWzutD1Zdgk0TBZ7cBMGxbIbunOau+HpOs2e9rNsWwCxlNhiZ1Gru9kaxAX5DvLzX487F911OBQsKgAkqyzk8I8xJv2TdY8gjWT8FUeIhIO9sJRekbguyg4Q4Caie9S4YQbtIsEGna4aNlnsY/5r4ptBHrgM5tiAFFzx2Mjr07J7bnkYAfafamp57hFBv7JdbVmKeeIedUovbV4IZ08K5O0LYK1GrrMRygDLmAIj7FPhkSmGpVyS1MMOaO9kPt3gsmPd+FJm1wjQtPmTNZCuJ5+MOxQ1T35i3ALq7yY7fllb7m6TqvcwdZpsmddz0f+gKSFQs2VmF1tF+f6y7qhTQXyzsqRxjBG7icRSDUH56x0fTsyyaIR9l3ydO29nQzSpjOz2O6kRjYRnRDzTD4npK0UDnECwQBWXKIdZST8nLEdWP8vfTr1Mx4grLobvIxCf3y+dba0m8XRBSTTZf/VaGDwe6LaC/RVFQCzPmJsGOPKYDxqDWccFc2IireTOLtycjkZKL2AKb7TKWMELU6zuoLtE6XD4JQUEQkQDNz+OusE3BzmshE4ut4rBp64jwNsXDZtCoR938k//tzgsm4fHqJX3Au/KCBxsNtku6Id108ihpyzEYwcZMd6MDS0vYEYMfkx0cPIFvKuqiMkwsWifTZ8SFiY/P9psEc3i6bgkb1YdHXlXy8mSVoVWdopKGp/U3obsqDG7J1aHwqqQkfD+7DpMDJbJPy/RfZBBF05DGVy0ctBD1sq5PQdr9Beb0GqX/x+XYZoP4tMThToXJAnPngMdtbu3+Bq9n3gvYUwFJfWp0K28fkuQtaKdmfIVyQv70jKzizlaDR/Em820NftxC71/JVorKQMCOEc//SZFzUqH8Z24SbupPhOOm8fWg4hDAQYArJ1BrW8xRHDzxtuHNSAP9pvPHfHTuuBGBgTwoAK0gwnLrAy7AwpvG7hCia9oaER7D7HJoZ0ELWW8dv0bCbPi8CJT9YkwYU6LrosalCVyj9X6X3CCsfRZBvgs5YvoZ7mf0GARgJgiarGx2LeW6XnuHm6pn3e6li5ViNjd59gGDzTXfSeRIRtekeznKwthIkncifr4eu6OgLKkhZPkEiT87SARA3u9OoDg/33srpkTsDGYWasJOZzbDn8IIavSbbwlya9DDfhUD99BDbE4mc3e5SGZaXSFGguzVabZgFVQEQpOF2rkuiX7yRqLDffdGZMDRh30Fr/tu/NBmTCF/c2L4tJup39Nxva1Vb95c/2IeUZKvA9AUuBFwgWki05WmQmQaibG3FazFfme5uyUxbt+X8clohqpn4Br5yQssQ/OT/W+jlrR/5po5/gcz6BP/tBhpMJwXBBuDTiSHm9GHa5LFm/Kvdd11Qa9P22Le1I+6iXad+stE9vN/ry47WTJiHyPoNW2r1nMqo3Ln1MbTZmyn7iPQjTHf0y8LfStoKnuJuXccBrVUQsQrzyCD8+BRP7c+ZL8hV9Q/Pdej+Z2g/KJly7Aj3omvMKbWMDGVgngwywRCuMDh1qiJDe8YbL6znX9YHgTf/JIzxcIBa84gkHAh7Idr/Z7odx72WhVIVcZJfrwcG2lzp7A+979iC3O/W8KonRtcXL/ZrXvWr34gcnlOhfbYL2lbyRyXjJKh672Qy4J5jK8G0pbclsgnCMdWB5fSqrHT5FkgTiuEO2TU4TiK3q+Cl6rARAgagTvF4wKYqBubAAbGGTYkBn7JpbVFLvZdUyqPsdzpO9+ZSWVJQpgnBgVF0It9rDl2ZK++Hib7BN0V2154uPYrMaIg4wJZ3FR8d2pZMK9Vmvca6E2ZbbTxtTOnt1Dt3sKp4upV5CmV4aSFkAa+r5CCGNgMbRR0974tluIg+jn1rmsZnL4G1Lf1INFrualn05j/K7osCCXqvyv6THem0TVIIE0KFgKglwOJvyGjArI4hf5C8Uz+P3OnmqF6fstCTSBNjMR7/6npdvOE5kq/P/pfe8OZ8lMpZOixNbes3xIasMADq+4jzIakcbuQE6e5gL54gq+FrGEfDs0rjnyKEIU0hdfgxgYJJSPr/YOtINmVyyJ+6plurZxoo+fa5mKOn+cZdYJPoypN1DvSjPY14V5ggNzBepoTtDoYKY13ME2P9Y7l65LypCDpPz5bbvf2DXGorxT4zAqJiqZiOKsMcNrso5waadqkgNUMd3g6CVPmQYdZKZaJMncqbTtgHILGyq32/qjFegaSvzyX7oxCXP10wvMNc45CoQLE9G5JQaS+C4nkTH09MlBsJz5ge3iiqE+kccDIiEisgk5tzIbOFc8VOumLoHlNv2z1wrLjFYfx+D3tnPzOdfBAu3r8qzttpH5QLzDgehpSSDhhvePxAeaBNPNCvvnLjLB5C257Dn2UCqWOiXCZCA3lHLgijM8weHf75B/M1SjMbPgNwVMxoWPOktpZ1zacnIpkzvszxwnt+cQFbzDwneFFtRnazyvfkSL1D+bq2rX72k+cDcbi8ilB30HTtPCQ/Y7glKxHC1E86aQTKS5Se5uXn/VzpAet/YModkoFpAb1EwZwRaeAOnvRyWnEQWlBA4wHywM21JBkGKoe3gkKuHsrPsjW/6SmUh9oBp9ye6Br3n9L6UQJrfL1wNxIAN+YDjNiN9Apq44x8BpDLpXt70dwZkGjnU2IpCeo991oXqH7mlotrHiK9F/fU5JTINIp5irTfQBdgytRdcG6BH6QlXzCLK7YrjWm4y1vHHKJIHtLodCvN4DlvAmBWEgKQ1BT3+f/C8gGYs+xoJiKXl4M9gjKbssE4KWxH48DH8eyErmYjw6NNvciS9k9VZtis7GE4NTu4WTioAczSg0HqEtJoL/8KcrayEbzYHk64jUZLCHpLWwjhX3Hf2SoS3qulxaieBFdeI06hgR6xgG4MuhR8VWFuyWJkDGW2OvdJ381961yJJ9ZXxEUHw3xAn3jviq3+fWCyql45Rx2uoD43i6ehpCLgfqy+FhBHPgTf9f5luiVXEHagnh1SXR7NSaCpe1i2xgPLaFfhoT05IvTgcRATcTwwLz9lxxUcc1y1uJsZPFuq9q7QzgZayTLVJQVSzHbETsynCUn53ESxUOCm5nbmTo+O5Ch42y3lzhxfXos2lu/ACHFBecQLQwlWCkgq6zU/AeELzPcZGkjWNP817TkM8uRcU6eASS1/n6g+Af8/g0nrfEdppgtDxgncI0MEAEYAISj/5T4saFKDyrqHyNeYEPq/V6+ZR/xx2EzkfSNmrfi5l12ThZLKayx0MkCDczq9cgKzSZJ2XRod2P2A/rzR1Mj23ocoO7HXhDi17CD1eiux4bOTPSM26B/FRVktNnlrRQ50JShVZiBuPCcckx3EEOd39zNl+dV75lALZHFS8DCZCS/EPTio60rwYU0Ucye44VzR5+A/pyFUceMEHCvp1eurvI749M3kZxrOsWxIOkLmqsnzNz5C76NLUf5Z2j2In6m9Q6KdDLT+WNOlFQ7TkXYExsDRklXxCKogjrpMx5sxnDOmOtxF5MLKHHLqeS5UJiWCkh78IQYDKMbpVmNefyiWcz8sYZz85ZanP3pOwrtO/9b+/cJwKFGZM68lvVZqBRtbDS1GfUg8335uua20V8iE4ddJ6j4GCuPdD66dKrtw9nNu3peMdm1RngLR0ROfTIXx4ONNzRwizLxdIyv+eBbNAVv7Euydzp8dNegruWiniC5cExcnyEGaj/0UA7USTnceYzCZWiFAT/c4/ES95p2MLrWqRepNSkK95bNCPRfI+DRJuvPPza3HrvBkX4j7BXrsP+o/+CdUotZBYtiDbh3O6EdcxQOuMSkInT1f0rGyKvwMdYTd/slD/g6bBYN7ZSV+1611ibRi1vRhP8Xylsb6A/9o19Jn9Scj6SB+6p8DG9ctZ5F3sD39Da2twdGc0YDatmNZFRcV1v8Kzz3e8FnLDxnhtkkrFHCnV+rtT2LpZE70Pnage3lJLzXv7pngRgk/5AsJHY8+31q7PTvtE6JFxBi0UzdL+Yk+sXNl6IPuBG1wFAwRkaDcr7lQkGg8PwDwLFwCzThOkMZWUsdV4OSvc2nd8dXx9Hx6nMTxeh+Dtb1Iz4HoBZRbbLy1DLt8b2jJdqcT3GXy+2l1MUDtnuQ/tcwIEyJIMsy+T1SKHm4klSbw5x0W64oxDEiXbu5MlsE4273LDxC3QnP2ccLboCiEQXr2LDrjfSO9GKJDo6NikPwbvES5jkqgOFHqjKqd7UQMVRR+0sLlmOHb3Y9gG3qM8EYqYyjp+3qLXVhDO/timj7GZNyz3BRY5WTYbYmANW/pubZsKo91au570JL+3VYF1Kt+wMaV7IRZCs/psl9KzYF0+K+axiMUJl04cGfgHEM3yMBbezM6Ilea6hADczF1sZrl6a3gzrF0zzfUY168iA2FOzM4d/wwOMbgtwpAOiFIep7uo6lWjvFQWUuQFiCkLku9O0f2OOuc9N1rSSjtlcgibKf8FcQ+x3GR8RyY+UyYFLRxOpMIP9X1sxZfT/JpiMvv1VT/IvaRENtF4vRjs/WPbNHqLNrQx9Cukt6hpfxILHr7hppp7ylnPK6YcZtIrR2yPqtzYWHRG77SSlXtEOkdx3eExxv3dfE7tEReTCIc7ON1/cwllJoqOA80dnxaEuYS+Tr0i32oFs7l2CMx+xCkc9hQIKj43c+KRiUJLKbL6HnXG5I7FM4q2/vbho8MaFnDHnL0AAIEzB64P1pA56tck0/6zfi+Jkr6+PQqxkOGTRIRkXfVOSax3ZdiH6Z5YjXT4u9/R1MEhqu9m3wKAPLOoMWP9SUamQiBTt1tBo23RfVy5ZWY0haZiTBKgRp43OjGaVj0X07WbRgN6ZjKlhA3jds4lHDWYultNKW3Wi6/yTCmK42w+gFGamlulfDuDRTSxlgTAgP6Ze2V6DeA3MrR8McoWTZ9JBhG4T6zafd8cQua9u6hj9Z5H3cRlnx++LvauG6mS3W3PqGw3KCEUOjgBDeW3iTXZfNM2FCeu4yCmqmSDegGCuKbXHToWABcGoJcBCYDpAAcLAQABIwMBAQVdABAAAAyBcwoBhgIBjQAA; VarID: ---
Type - Grafica - SymbolScale: 1; SymbolApiHeight: 0.00102 m; SymbolApiLength: 0.00158 m; SymbolApiWidth: 0.00066 m; SymbolHeight: 0.00102 m; SymbolLength: 0.00158 m; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniModE884
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniModE884
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: LFX_I_IguzziniModE884: LFX_I_IguzziniModE884; Famiglia e tipo: LFX_I_IguzziniModE884: LFX_I_IguzziniModE884; ID tipo: LFX_I_IguzziniModE884: LFX_I_IguzziniModE884; Tipo: LFX_I_IguzziniModE884: LFX_I_IguzziniModE884
Elettrico - Circuiti - Dati elettrici: 0 V/1-12 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes
Vincoli - Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
Name (LFX_I_IguzziniModE884:LFX_I_IguzziniModE884:...) | In | Contrassegno | Livello = Livello abaco | Quota altimetrica da livello (m)
9455845 | L00 - Piano Terra Piazza ELETTRICO | 5394 | Livello: L01 - Piano Primo ELETTRICO | 4.23011
9456093 | L00 - Piano Terra Piazza ELETTRICO | 5395 | Livello: L01 - Piano Primo ELETTRICO | 4.23011
9456125 | L00 - Piano Terra Piazza ELETTRICO | 5396 | Livello: L01 - Piano Primo ELETTRICO | 4.23011
9456148 | L00 - Piano Terra Piazza ELETTRICO | 5397 | Livello: L01 - Piano Primo ELETTRICO | 4.23011
9456149 | L00 - Piano Terra Piazza ELETTRICO | 5398 | Livello: L01 - Piano Primo ELETTRICO | 4.21671
9456164 | L00 - Piano Terra Piazza ELETTRICO | 5399 | Livello: L01 - Piano Primo ELETTRICO | 4.23011
9456230 | L02 - Piano Secondo ELETTRICO | 5400 | Livello: L02 - Piano Secondo ELETTRICO | 3.38473
9456271 | L02 - Piano Secondo ELETTRICO | 5402 | Livello: L02 - Piano Secondo ELETTRICO | 3.38473
9456285 | L02 - Piano Secondo ELETTRICO | 5403 | Livello: L02 - Piano Secondo ELETTRICO | 3.31554
9456320 | L02 - Piano Secondo ELETTRICO | 5404 | Livello: L02 - Piano Secondo ELETTRICO | 3.31554
9652250 | L00 - Piano Terra Piazza ELETTRICO | 6147 | Livello: L01 - Piano Primo ELETTRICO | 4.23011
9652257 | L00 - Piano Terra Piazza ELETTRICO | 6148 | Livello: L01 - Piano Primo ELETTRICO | 4.23011
9652525 | L02 - Piano Secondo ELETTRICO | 6149 | Livello: L02 - Piano Secondo ELETTRICO | 3.38473
9652577 | L02 - Piano Secondo ELETTRICO | 6150 | Livello: L02 - Piano Secondo ELETTRICO | 3.31554

# IfcLightFixture: LFX_I_IguzziniModQf61.01:LFX_I_IguzziniModQf61.01 (177)
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniModQf61.01
