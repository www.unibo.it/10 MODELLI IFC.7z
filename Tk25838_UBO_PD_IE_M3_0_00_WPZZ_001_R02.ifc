Properties of the parts of a building model (IFC4), part 18 of 23

# IfcLightFixture: LFX_I_IguzziniMod.R664:LFX_I_IguzziniMod.R664 (136)
Name (LFX_I_IguzziniMod.R664:LFX_I_IguzziniMod.R664:...) | In | Id host | Contrassegno | Livello
9746570 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6261 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746596 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6262 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746620 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6263 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746635 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6264 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746650 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6265 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746665 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6266 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746690 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6267 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746691 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6268 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746692 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6269 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746693 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6270 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746694 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6271 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746749 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6272 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746772 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6273 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746789 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6274 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746804 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6275 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746819 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6276 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746850 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6277 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746851 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6278 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746852 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6279 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746853 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6280 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746854 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6281 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746885 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6282 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746902 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6283 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746919 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6284 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746936 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6285 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746953 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6286 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747021 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6287 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747079 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6288 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747098 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6289 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747205 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6291 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747229 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6292 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747247 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6293 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747263 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6294 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747281 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6295 | Livello: L00 - Piano Terra Piazza ELETTRICO
9747410 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6296 | Livello: L02 - Piano Secondo ELETTRICO
9747439 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6297 | Livello: L02 - Piano Secondo ELETTRICO
9747455 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6298 | Livello: L02 - Piano Secondo ELETTRICO
9747471 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6299 | Livello: L02 - Piano Secondo ELETTRICO
9747487 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6300 | Livello: L02 - Piano Secondo ELETTRICO
9747519 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6301 | Livello: L02 - Piano Secondo ELETTRICO
9747520 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6302 | Livello: L02 - Piano Secondo ELETTRICO
9747521 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6303 | Livello: L02 - Piano Secondo ELETTRICO
9747522 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6304 | Livello: L02 - Piano Secondo ELETTRICO
9747523 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6305 | Livello: L02 - Piano Secondo ELETTRICO
9747557 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6306 | Livello: L02 - Piano Secondo ELETTRICO
9747572 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6307 | Livello: L02 - Piano Secondo ELETTRICO
9747587 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6308 | Livello: L02 - Piano Secondo ELETTRICO
9747602 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6309 | Livello: L02 - Piano Secondo ELETTRICO
9747617 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6310 | Livello: L02 - Piano Secondo ELETTRICO
9747650 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6311 | Livello: L02 - Piano Secondo ELETTRICO
9747651 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6312 | Livello: L02 - Piano Secondo ELETTRICO
9747652 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6313 | Livello: L02 - Piano Secondo ELETTRICO
9747653 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6314 | Livello: L02 - Piano Secondo ELETTRICO
9747654 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6315 | Livello: L02 - Piano Secondo ELETTRICO
9747685 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6316 | Livello: L02 - Piano Secondo ELETTRICO
9747713 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6317 | Livello: L02 - Piano Secondo ELETTRICO
9747731 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6318 | Livello: L02 - Piano Secondo ELETTRICO
9747747 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6319 | Livello: L02 - Piano Secondo ELETTRICO
9747763 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6320 | Livello: L02 - Piano Secondo ELETTRICO
9747792 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6321 | Livello: L02 - Piano Secondo ELETTRICO
9747793 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6322 | Livello: L02 - Piano Secondo ELETTRICO
9747794 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6323 | Livello: L02 - Piano Secondo ELETTRICO
9747795 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6324 | Livello: L02 - Piano Secondo ELETTRICO
9747796 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6325 | Livello: L02 - Piano Secondo ELETTRICO
9747825 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6326 | Livello: L02 - Piano Secondo ELETTRICO
9747855 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6327 | Livello: L02 - Piano Secondo ELETTRICO
9747870 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6328 | Livello: L02 - Piano Secondo ELETTRICO
9747885 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6329 | Livello: L02 - Piano Secondo ELETTRICO
9747900 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6330 | Livello: L02 - Piano Secondo ELETTRICO
9747929 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6331 | Livello: L02 - Piano Secondo ELETTRICO
9747930 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6332 | Livello: L02 - Piano Secondo ELETTRICO
9747931 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6333 | Livello: L02 - Piano Secondo ELETTRICO
9747932 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6334 | Livello: L02 - Piano Secondo ELETTRICO
9747933 | L02 - Piano Secondo ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6335 | Livello: L02 - Piano Secondo ELETTRICO

# IfcLightFixture: LFX_I_IguzziniMod.R671:LFX_I_IguzziniMod.R671 (108)
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniMod.R671
Type - Costruzione - CFG_: ---_0001; Mounting Place: Ceiling; Mounting Type: Recessed
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: Q807 : Round recessed luminaire with contact frame. Fixed version. The LED is set back to minimize glare . The main body is made of die-cast aluminium with a radiant surface that guarantees optimum heat dissipation. Metallised, thermoplastic, high definition reflector - wide flood optic. Structure with die-cast aluminium external contact frame with a single white finish. The internal ring is made of thermoplastic available in a range of painted and metallised finishes. Safety glass included Quick and easy tool free assembly. High color rendering index 3,000K LED. Power unit available with a separate code no. Q807.01 - Fixed round recessed luminaire - LED - wide flood - 10W 1200lm - 3000K - CRI 90 - White A04Z - Lamp LED Warm White CRI>90; Modello: Q807-01; Nome del tipo: LFX_I_IguzziniMod.R671; Product group: recessed luminaire; Product Name: Laser fixed round; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___q807-01/
Type - Dimensioni - Height: 0 m; Width: 0 m; Length: 0.084 m; Weight: 0 kg
Type - Elettrico - Number of Poles: 1; Commenti sul wattaggio: 1; Lampada: 1 x LED; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 10 W; Voltage: 0 V
Type - Elettrico - Carichi - Power Factor: 1; Carico apparente: 10 W
Type - Elettrico - Illuminazione - Luminous efficacy: 97.2 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 98 100 100 100 81; Color Rendering: 90; Color Temperature: 3000K; Lamp count: 1; Lamp Light Flux: 1200 lm; Lifetime: 99000 h; Socket: socket; System Light Flux: 972 lm
Type - Generale - OnlyDefault: yes; ModVariant: no; ProductGroupID: 4; ApiVersion: 132383237; ConversionDate: 11/12/2021 1:03:02 AM; ConverterVersion: 2020.2.4.0; RlxChecksum: fccf80322e27ea06f4ba35782201e60d; RlxData: ZN3q8ryccAANXLxLbblkAAAAAAAAkAAAAAAAAAO7PqtQAf7Yb7fCEQFjjkd4QJ1aKGDWGpUsPWGh9Xl8R12QHaDwZtMtB9++hxH5hdB/yUbcVMaWJWLsY/LJ0+F2mUFnyAk5QrSIIzjjLEQEPnebmKqthBOqlBJZ5KskzoYNW98D3hNSny0q9qMNIAyDGDcKNyAnTh15bk1wOLotQx7M3geEtaJc0yBrcFb/qF3P6IY8WDeNMrkIzBlC5iqi/SJBEtx6vJMDwjNoYnmUZQvwuG1T8MqlA/tX4tHD6uClumrLG/9O368TnUwLSSGP/FqAefwi6grJeE8DOwNirXQ68lZ3+uLleMNHaJOUaq07vLzD9UOM3GneIUB7qFMjgUFGu2b58S3/my8EHz7TPVSiNu2xWZ9iAnaOsFWPorKJ4HUpPmLmkOLS9BowmxkSErfTCDZj6N6HvDU7c979rKx60N/EEdz2ClwRFZtkopACe5fsgSmiSgYhwv8y4YYwLm9NtlKR7wjLiAgTMnKkARt40IyoBqd1FlvMVRVJuP3f7uARJu1U31eK0QthDCw+sz9vX2DGQveLf/BB9ifEi2WLZQVyHqtAsbmc2ceqzL6vEjWcrIwtY72DBZmx6BZTpH35KHptLYtfbWOC9M1yxOEmndJiN/jWnzyWdnbOpWk25gWv+ilz49X/T0HCwhXeBMy3gvaWKsAjEnPSon1fUFZucNNQaXSJN3DzzPceRjUCRF/oFA1irrnWH2UEJGzvAsPSOIOa/3oFAT4PFYYpniOZi0MZEV/Iml0nKlY6BYxCvO8fgmjpRE0Pw4BOulzQ7PsCtSPWMfBfHfa1wWKVPqzJuiP+U3EVbwDfpTTYrpduYWiiL6NLvelNhaq3lF/cWxXbTdx+7mdmFJzi/X5r8j8ZLAWw15W5SKgvmQKVFUxpcAG3DVqkLxSahzi63CmQy7GwMeGki+mPNOo/XXz8X5DT5J6fl5P4GYlIOC7YivBhxEXN7jRJew8Leg7AMJrtjwi0rsDZefAI4E2h53lBAoQBSe58Na+39ZkEQYDrkQZQm0SrsHhSaKpqBxq8AvvEKDaQgHXxiqKtVLwe50NiPxhEn7+5T9NlXTJUa27sH0tVJHHbMDWqVaWwncD+zgBuIG8EGxhJHB185IcAPVBgFlm3o4kVYE86bBZ+bMx5Wx02aP72V4ABeCxbWTmEcVnJrpFWbnQv5NUUMwDIuA8oFLUo+4UTwKDOqV3GCZX2BplIKNlEqGYF099z+gFXYlmYK+1RZLCeFalVA7LARuBlXvdb4qlE9yNHWa0y1+Ir0ETv9IYigTh+oCFmVBnTZSkFlirvKJiq3HLT12bVlav+TcUerIUew53kVyIx/tyqu+6DOD/i9Em6+AhDnj5j1ULglyF3gBnGY/QTIGLlkY2+4TJAmZQb7eqIFrAm01j2yLKGsRMEViyBmULbg1DegIl3AutmJ2VIBQrDnzU71NTnzVtvdk3uvwpW7+NRglCb5Sw7c5GgQqR4sGrGkOwwgkXpoUm7XSPhQu3y15u6CR0vUUiCxUrOuXd6OJeYXEBqXS9b3T7Dt8YNgcxSr2kZrBipzGGMAPFCmkt/uc4gIjXkLJztU1boTlO27c2EbYcp/anMcoCKzm4H5KnDHmB4/ME+0wi5ccxbwS0lexGlkKuy3BVx/qpwS8RGulsbkbXKpWvBHJ6NVMwXRByfJp3LsDNyOgG2jVqOUDLMABZMU1n5khvIMRdFI/A5sBKRDAg2AtZfmHx5ECNt6mKVVnPJBh7JS4vmTKVeagP+g1v2G1nJUQ7iKcPJ83OVT8VQlLMkTDOBsbzySsoOSJtG2GC85TIvMvS0lYY2e73Vwtp8/1WQnKvR5A2f0gtBbujPko9VLeGSSzWyrs29bp5S7UQ2YD4DQLIQgZ61RrDoYVBil8qCgdx+Je9nog81YW8DsX5HfA0xRGrOKBd0oZ3bOhhyFEIAhVjr2zAUtufek2T/gMUv4r9dz36OjOtN8zdQO4TGmfbWl3KMM/0NX+H1H7MgvpBJsJnArBcyQgQqmQJ209Jwuz9aBLktB1vGGiHrVsNpTTfkv8QEKm9zmk3T6TlFlgXyagQf9VzPc0k3dqVXznqLw05KHBwrF2l7e6ODgeOdTClKsvQP1okHfFckI7ehj/ziMNpk4ghJ1RpQt7tLeWnlF+gQ7ZiV66TW1cGNHVZi1rd3TroGTPBaHIUmlD8/IUFaRXcq5kb9kTnMLIBWiBb9lbjHs1aQduGrn0k4qx7ZyL4HQ7NvPCcKIRKhrLvhqw9jBd3jcPfJhdRMBf1TFnP8n862BWhfMeiByXBCbMwzU1hMe5cccUN/C/5kYhf0EkEtD3yHCPsUqq5lebRl4kCEgT18zj4j8fW32sAdrR3g6qwaUJWnpgv+dS9QIyWFjlyoJonyw0CCzI51tQevuduphGowXBS28iCkguDT6UJvPhs2pWR1fUn3JP28AgnhMCBNZKyKFt3PXcsXFZpYfNDRkpQ2j80x/bcfh3/juA6GlA9onRG5vekvXFh2GEntecHLNUwfuPJ4ujqT5QOh0CEReX48pBIyJdmQyKvXNMuOk3NyKgcmfy1uBej6WDb6MkCtypeFyyD74UTyZWokOZv2jqKylDpuCW8Afd5Dtl4sjIv3aoQqKW2IyfMuiRWzjubNuRd63xxiF49o9qSNVHAxJJZX7drhlteFMj2X2PxyUyAhALvBe0GhHPnDG4BUXIKVSNNB/LGFWNl6a14j6uPCkF5OTkwPn+pVvnFClA2yh2V2FDM5jJiORubR8klHb15FN3byWfPaRkUxGIw/a7w7P5GkvgxoZFUEljhfDyWxvsdUIzDW1BHqn92ZGitutJL52Mt9X8uOXtNfD7iMbCvsk8U/46QMFn296sDXS5kSLA3SoN7yXcHNAUf1PtTLHIg1Zg3kKmLlCl3S/QQ+Ju3+QhUJ0RSezIZ3/5ziHcyBfjhrOVdolI/h4+sKhCRZ/Rj288+uNeYqabHksRC8ij6z6scCDzhVF38PKEivd0djcaWkM0wr3VJCew1jGBgsuk00vdIMPZQWFFAoCQZR1WdOi5WalZrIqwBhFVxWZP3U9PO6vBik/ieo3ck/5HngqmmvR7mEmNTORl2ARniD5wfssFRcHCNTnPfZbTRQdeg2hmtQAaQx6sBuXoVtUHqyJq43mSDKGAYyV+Aa547pRUnBaXOpfQbg+R4TSyZc1e8ZRq2xpt8Zkc6RLauw0zTG+1YqkRqCxNHZBrNFq0sh9xPBLLCSJoRM3+Mg6ySQnoH/HhHu+6Mqi2xnefvaKaVqHkL2POxZBT0ec5r5meF3gv5qmicmY/8nd823qdaNIlCX+o6nQl5G0xCMKaRO57gBCB0XHZH6rHAEVMsmtZJczp1Aywa8MuO3m9D1+hFvi82baPRotiA4/+ZixMJVJtePgc2ZBh3HVTK0COCzN0ZoHWyZBTiRzCSIx4s/B7TPzHMmXOvvCE1HBpIBknJVloljBUi1ziBgfK+cwd6eEOwGG1efLWNl+28LKZ3AWEzWLaD/+JHxjOYLE6jTHblyRx/fAOBmIAgRWmIPMN1bLu44GeAiTxm+GIZgCRJGer7xfqaDs2TcpAh2KxE76JekF1ji3oO9q754eZQ909rbirI0BcWMAm40iOCVBMbAxNUq18jsN2eJbUP+PhYHc9gEBcEZYWVfunzD0RsT1yT6TNqaAPBdDKFAyuqZuGZhaIktin8P5qWsPrpa4PocLbFMGP3HiZgx1I80fMaHh4G9/2+sZyEJFwtbqjLlIwjqTN2SPXTYkNCc6bCTclSjS6Ck+1Tb2yBpvCDUKGgCJRZQSEkwxe3Uvh1yR30KBA7DyueQ9Ghxt7l157sQnjP3JuHvzBOWC4Rh14jR3tJZCf4IbUOrxbD0TVZntr3trvfaaYOpdcaIHJEF77PzrbTgM+1tLs/R+YMYeXZ/DHog+P5m+V+RwGnHK83vXREw5vNwJ39t+58uz+HuJR6owv5fbIT0KXur/pEZ4KffzCYqAAd9t4rqGGCodIgFw1PP0nKA5BqBtcQLS3454pT+Bzm5M6dT6iBD7NXHGZhmYSnKGoli3VZVrWR96ngvxz1ndz2BGWsYOUV25Fbzpdv+YAFUzMF1jj8Gt5DqWjqWxKSMkspX1FSodN3ZTjV8XBbcuIUzDtZIakQshH+NGlmnuwEAyYf1ttcR786J0RNMdduq2s7pbENRBRAQV/Fu01EQV3eIpjH7QTug+Kuact+IBDOmRsCs2wc2HA7VrAV8ACLMch7sMRqciLQ5vbroH0TA/g1jhR88mV7O7+gKnCaSH9AoVEqHf7tNbQmW6qvWMBOFjlXdl4q5xXfcOiL0tVN/wZv0fAMCBZfD/JFBODOmdv0PLcPT+In6fArU57y5pCEpdhoXq63vpRjbtubpj3Riwn+Vb8nNl2DsygS2TGbUdr+buyacpZFA6iWscOwiwAe1Kff7xjG32wKRCoVIaBb/w39Gp/qiY57weaL2g2QGeDZzHr0DW1Rgfq1YXpp6PM6Oye2BMsFI9jf2ejP9CZHf77eBFoQQ1s/wRgE2nBoGv9/sdN1WNTc+U4HHjWx+eINDRr9et5zaraucBbdj9SokjkBZdhCLAPDVxIy/QRlcSd2UQk/RApJyDVB2XWHNsh5w9/s6i1/pMdv6pPGlPsBc5NZa12/UybeMJ9+zaG0acGDczLrNtXhz1+JSuEo8qmYbbGHjiOSE2ASptxC98LtMB1mqwKvHOBPDVXnTaKF5vQnO/7A6lrtQ5EWjnigswzoJAB/wVyQo/RxBer85DrtPnHZftuOYrif3VT7FquBYOAQ8vRrdgswP9+d6yAdT4jY5CHKI8pJl4QpBPFqJ7ABVdYPn2qjyd8+4yRMsoPvng/N9i956oYuNzeDohbP2r30jk7BK8gVEgLlnS8pMmm8hAA+009gU/eOu1kQNmOj4XmRAzzb6YL0l9DbR4LGoGPn03hnuu10xTeSAg1VzdO8B/6en5LINLZO0NyzYYLx1oJT8e4N70z4MRFNufGgjs7VqTnGE/1lRYs+fTO0mKGj6G+Qj/0AX94rZKLvC/u5h8f8LbePrvp3ApaejcZGJTxvzdQHjk7iXuQTzWvg2C5yS3QOxoAxLDy5vdo6/pV7hZeUpjchd1X/ekmAi45hYUzuRSoXQy17TqYcRiKbh4Pehn63LYnn+lbNLdBdrFV0egARdpMBN8ctQofXjzqQOjpGtUZc79zcRs8PTCvhyspxUAyXydYpU7IeZGUGGI8/Ffzej3M7+EDRnzoP7Me7Xy2pjiOJTau48K590+NGfG9Walc8aLiU5UD1u/VERwJhQu8txaERkgihFrCybqBH2MPw7lQsUsJ1ANXrekZw825Q0GGnPOn2Sf46K2nCmFHd2sVo5/XltPzwfcqXfb+rmayqT55sdiIhiE3kwGcSt1YAuCe80xwYEPN4MnnNTw4zxKEXqvZR/xE5HisxQp2yn5jPcO2NScz4tS8joQ/r79hEpqmfS5DE52UFIY4aB3u9OkNPvnHEPjA9LrEu2UMtR5fnTf6oaMGxN6KIKhvog5tMirbaURJVd8qmPaNgL3PlAChRVuwOcMkOpmfGrw8/4BoE+MOSFfloYrULzGYGgNNz4i+J0ArX07+eOhgc36LNYXc99Bx54SDPlGiXWN/5Kr//pokWbB70iUWiVRDHrE4B8fn8ofkStZMGj2LrJ1NNaNXsh4owVvg1jOFCSkgyYA9Koz6W/jH39VJJVeNrwaf5J9t2dedE/SFvQZCN0X8FtqCOMN4dsANWHs1RvbzlwocHu91ErFl8CY+h/XsfeNOPRVaGmp3RmCLbM8pipp40kU2BAUHV70An+sCwRdb0F3CC566QPvlQlNwwCyEklERj6QQ2iNnmAknpg29LfSpgxCTakDaeK9PCjZFeK6JbgsTZAsNlPM3R3fk2IBASg5+6hSiOKa96DKGbyiwRQEZjhMc3na4s0hW2klReYZ4Xb8nTNqv4FkTuxMPEsOXL9/atZsrb3kokVBaCNuoOfEVHuOB2Xud2iWQ8DDZNK1jRfp5sxYLS+MUkhIDV9CUDr4OuRRrb+eeWuKQEMWgjRIrcomTCrDFiyM58E44SfDGU1Ai5fWR6v/J8/j8a0A3UHKwCozNvku/DPfnv+N3otl56ky3MThpzy5NsmYkbC1SBofoOHFeqxTr6bDuVvCmQdqY6jF5HfWLN2u4p6S4/SO0XcrtJ+q5v9rIpzFgBja4fDxUlmaNXlTuaV3phieUjpiYvb6+l3ADnpZoEnUq6l3rKhhZZtMFJG17UKwcc+REzmEsywpZiOnME+C0WHveHCDTNeaWkGNarcmIKEwM5QIiwlLqfOTqfabN0fbtJIiVhPKucxETVBzkEKr5DQzN7KpnrZyV7yuBKVKVloa2M1eN7zKThagay4dl8cAdfQi4G7OSWFBc1n8EukltNcFY5wJvm1HFG5gv0T0TJFVvkhOqVgDZf2F7n9kulB/TxotCp1OmAp0aWGi6JgVSjBVeDIM1TdYuIzxVIM00aa6lYlQp4c2RFKLQV2JpQx255opjGrrx+sb8+YN7TpnWil+7o/cZdJBOXLxhmdvlx9fGZfwvx3zINBw67zyRfX7K1y7WOSEz0QXkgL8vEdQB/pk6BUD2Zc69DFCN9SNwyjeKFk+PflJ4AM1bVh/YFStRNoDATLbwuTB93N0ZbeChjDr0KOx3NTIqZaMC8QVYhKSMZwSsS4IfF0wZPHgI898l2z7SQ8sdmXoiXFEBSKgRpsfoA0KOajxUfhH/7uAA8b2DrO8pukvGWIDhPLj8YcUjeVEsnWjRC2LS/lqgQ7rCMxzhtX/1iEG+jW4wzDVehaCAnIoy6A+6Td/2JPKDrhdRMyOnvjaEK5FWUlwaaCv/L/ND6ah19gOnI95uoiAHPUHTGhU6a+6XGEbBRUfwzLaDec0zlevs8HZLxqpcY+dPmBfhlQDMKC1FF3aTfAyJJ6F0x4wJwf2jAkrlvlXXun8Np6k1zSUxtrpmN5VVR3fEjTA/Y/G5RZI1xdnX7yN94iw64C7BvAPD+qLwSwDxBsY8fqy9NQvLeM6l0hR5Ph2bdtBeV/ckTUk4QXG8jRsZz65HCqzv+8cKllBVtk/8633OX2NTBeHPcLkDGOjf3IGBM2CgTY1/evGdpp7iP7Ci1R3Hl5UbzKIukNXNwGXqITcnvzGiz1GHB48Oh+BI/N9okYGuqzFzaYM1JAsAnIIxFchQX0ji/2l5XpY5+TDLsTybQXvc/NzTOZoBMjCPFQQlNxdhzlMX9FGmbVX+4QpUIFgh4DwDsRcSko//50QJmv37CHE+HwlEtsx4HfKs3T4168XybBu2Oanc839b7Rw7B0czl/8N9x6pKR91gRl9jdJ0nLkXsTeX6zw+ULm/rSinhVSs8byMcSHelVyOqXEDN1dMGu8uiJqoRsDJDXo+bNNTZGIHrGGb4047+wbpwzitKrhv/F9wGMmfKVgTgVpPoplWHxL1m6iz7IPKTTIPtkWftjzHFDjmLVJ6qRBDdbJ+3MtIgWRzpVc6rlGRJUyyZxzxOKbML8lrGNTvs62KCp8DIAt4sqFrGtOKpa63hip/HcbXaxmJCiG6vctOpon2jqG+J3jUHH3qngg3/GN84/Dm98f0OtK5wKUhqQMA75yply7/X0+TSdwA5PK3dgv98DhegvEYXn2K4ZSkrG3ysnbKiy4b2AFjlzcbcin4xxYROiGi9DLeWlyr9RfPS+QUYIGHFjF3VOO7uDtVeEqA+f9Vob4CA5z8b+iAEzzQ0ymq057WqdExREq5R3HWjEG5DxK/NeQueoCiThauTjOowCiLdQ3J+mVMK8U804eId0x0X7jAmUko4AGz+OepjeGXgsW7DHLhHox05PWCgAw3M0bo8wxf/FmGbMxyBa0iZNLRKavs6YAtRaWVv1Rv5OmLIaJsV3G23nbSUP/xmrsZfgZWdpEHG3aKZ6YUDtyjdr21LArTC4Si0hqA7SprmHqC5hZwG9rzwroVZhJRHZXoXymovlU1CjJlXJ4FYYxuOFlr22+j200/2xDaKFYCNBGOO7FmZPLq3N7SwPFC87iygQ8ac78/FRHwV0QW9qHLchIT27RtarsuYB9+ACCZSq1pYUVfQ06rTJbqo1V8x4cLa1PZbp4Gp6mWzwT574byGXPAqiZX0GtNiaw9mSbY+1gAXhAOxWxwBGe/q+zHWZn8NAuHW/RiB8hi+CAZu3vWczgKciQWd9TvFiL9fMLlqQXdoohauErGOvsIk3hGRtJmuSvnda51zeWofNpil0YKUP5R/IQGNRtDQKmzTRn7fMkyrbyWUJB314p6rsPVBLS8J0dDUeXOOIgvPU09mMvYkC1zW8g38OJEfcgutr/DinyKPNMLVtUGHgmtm6hVmuciIjD119sFgOyAnu3R+7NInkFTg2wbTZQNjxXFhNMaQiAg6aHckvwZH3a7KGAdh34LYaxUjhHHJfaHPZtDakIlH58OpbsnoZprTYA9r7jMQDCoJXqMSIscNWMbfOo9jb7IkbRDjfHjqXvzlpJQf/fHxYQ48HVkM6aw7aGdt0zAWg5UJfR19u6BBjV3xOnfSr4R6PhyEslRf1RUGf4l2Im5mdfv1vafOLdtwK0FTRfvq/to99CCkQF8RKwLhOD0RCcpmzetiQyNCXaObsQxWGDic1XABAGv94gVH0dspyaCva8rA8sOpOVRKYz9eX4DuBhywWfFjJ0510HiR3okZJHEQ9QYoEg4W4CLlY1pWKFg+X+Bh9+/J3JGPs56dbUwNG2QcZlK4qAsFtB0d7FeHZjuwmY+uApf3vavobmj/ohj9+cPO3miqdIvHsI9Rg/Pahn6625ONoOGzRqio/XWX+b0+dUQzCrB9GONArX90lSWMpObJv4L63VyKd430Xabyar0O3/ucjucD0GF8fXxZcqopvb3cBmUChOAGi6IAHcXByxUS99iVbPhajy5axvOmoW5zuUsQA9P3xNEyqhUbrLOKr/7jgVOseXuXJ52J+hAzpk1wBdvm4v7igc/YY+we6iNtNKad/j1vJgvvpPz9gcfjHOVP0EDQ5vyTshvxUhCOFMQGrA5vTqaH9nn6fdW4ZRWEZgvESGUxJnIF7PfTt97osHioN5a082piJHC8KZpt0CuKkIwga7s8JwiUDhTTQxWbufBNOJv14yPVWGRzcQg+bjQM453lVXFfJkEtE0l+V/b14P0DXHm3/g7dGhZnMhh93rmNCWjVGjrTo3ba8jJ+5T0d/3tmbiv3LbacDGIQ2x4vxBBn49FKy1bAR70NM5HaLukWgE3bsdXkRU+Il5+LIDgHXb9XgW+IrPxFo0wYpgkX1KlwTr3LVJ8e4WvmZnTfXpRvoqbHn0jg/XSvNGOlD04ilIaMBl/I0CJ96aum5yBb8lLEBZC6DBybQKK38fXkhK3le+1edxRZb2BaLIa4p0kcYnFXh2BBS62AcnWY+n2YZwaV4CpvA5YplG5U8ihRjtJ6/KhoGpCIpPWQhNyi/oKMwteIrBHVfSFHAXRNFUpASEnXw9Ou8Ui8aI9Hr+HCuQeXweqj2vG6zh7+ax+SRl+1SVnCNYDZcsvf16+dMfnkm0A6qw5DdGjOcj+BIf9pTpOtPXU6yhYIx12kxRohyegaebp9WMrBZF7rbAnL3eEKiW98esUjfZkDiU0Z8LyZLD58KsM0sn0LaFhnq44NPWrNtdtHxxxkHmkLkLP8A1ufRQREh7MgtdDCsKOIP55FR/Oe6xiJLzvD5RpLqDX0rIkTUK4bOe6Y76riAGCDMvhSllkDK7Yh1eBpn4c7HljUKmKCuoLurn1xDRyF0TmJ4kjZenGhTcgm5mdWAX24nGnoDskqV1SmlhEiKcAN+bcPj+eGBgdJyCfUAK24ieyEy8vB7Pq+4sB783XqXjkIi92xApHyIoRMWr/TmEu+pGBX/JPD9kGpXpDGqt1r+8TUBO0l6IcyoXeJ0EeWYtdN6IAFFlhqjSzOUJvUgeJzYdkRHRSoNIqRS4s7KVV4+yFFhSrlIcQSzupfUT0/WwPxIj4N2FZicVC1aN16w/ngrWQT2cTD01m32Od4P5E1jMZGuiKKUz/kWhde6A/Lo8XBelaOZunO5ldsOQFPu85ruYJOGb0PBo2BNTP8V2Aj5uguybnJI3lcqeU0cjc4UZ84frNdDnc9arpY6jU59pLd80gaI/kQS1ljaOTukulhKXyKTfC4MaewQjaVbpzqgdwoHUkFFMKyj6Db94uHbL5RaBbtRiB393IerV4RUW00UvHoMW+Cp4T1R4YKCh5hmVl+/DVu+n/I1y3JZZN5/3oWwPtlMZsUKTSl1TodEwX0rqrPXGPS64efCTsUv6xbubpUMBLFD5f3XL0rbq+uMToO4tDT7hprU4Cjmd73PVTxeIe0LVpvwduK/zMrawFroEy88yM5lLREy/mrLtG+iyuvQH6HlII1KDhZmXZISIOi5oTE8y9nXCN0odunAXYO2faeQ+g5IyJNSC11gMLbRi8kYPoewChoKEgZroslTl6t2lTikd0SbdpSbzqHvDoJlnId6dJCNqPcW/fex/E0BUSIkwpJaJjgLr2yfIGeaBy+OVVVL17FV/yld6ncrpV/Q/VVf36fkm+AhW3WuN28xKn8KlxM5ehf7dcofZ40TkpRO+KhYwAlRlAh794x1L6qU/e0DDHZUP55PfHiADSnMxh3AKQ+P4HPOtxheODGTDc8PCV+JhFAMBrJMLlxt29XgagoEItd0ZF3QOqi48CW65SSV9sp/BIi+eh/YqolNN2OtdjdG2C/FCOpyrSHrXIA73cD3uf9YtSnJTgwzZnRvHhZ7O8kfRJBl6DtHSPEG0dzLXer7MNKZAppiUDLwALQJXq4dMPZhKdEVZD2iCOC+LUPZ9yUQirQqE0dhqQppGNrx7UKFoLvi0JKCr5llfCLO5qkJVu4M8PHUcu/FPxKiFung24AdhWEYHHEh0A2U2T2wiLwnzPNP59Y2XSUDrPSFjdd8SmwmJGKBQT1kN/4i0+R5pwoOF5gPuKFdfg5q/kLfLBN9pLSTrTl2ID2Pp17/e9hf17PXjjTh2jRfvSvTtSyukJq0yZspXF/3eiA32fX09sLSetiPHoYQYhB5ijgjx8bUXd8Vki2ReA+faInIZrBLLT7Cy8BsDnyLGl0GRDWQQ34XRI27C69cNh7jWpkhae+B7rsrBEUFyVQXdY5/rw+m+RbHGBuey9CPLywNaw0D6q/PfYHUDGPEuTmfzPIeZDXUkOFZ1MlU39YjNV9UR+qqDenBPSXkf8w99kvdNcLiICfRT50a3rJW2qAdNAhrwgSCFKGFQ6Y3VcEnWt5oFLh5D0YE7GN9hJNEF89pRPF1d86i7ICD1jmpCIDz5frnSWPxLCMfh397Iq9lPPJJh5tnPbo6bNiHLk3RlA+myW5uAjQ5lt08OE4xNfZkhNpwme5Js3E1xpsyyyOxnYc2xussfFZZ9x9NOQHl5yf5mlIerzKvOnQHaSvzsNyrxnt1ZFT6+OHQnkqafH6aFLaOmPBCx0lX4xNNlOcnKH9d7n+SosZZQbBf5plLCKH2B0FbBtiZKGNk849jhUsj+4jzLL74pWl6BefvCGzW4eFkv2YHW2W2NciGgTB4WRRJXFFMBdmBYJiDfFy2UY5uFpPqD50C7yZfdOb2mCFO94OM0pgNYP2nIEmRoFrzvKc0CknTKQH9wAQPHlUNl7I7TyREP1Fc44DATEFWH5JIcetrQwZl+WbJEp6mo3Bw8fvIqhxexFC2QCHDFt136SsAXA4mmwVRzWkqDe7KVpHtPQzh/lH+Ng5KPfH2Fm9drK40h4wxozG+DhlfiVUGYcZ9fUTuWvJRbN3q1zIKUBTYzygsdDLkY6jSWTb8vwFPWowYHHOi3sI38YTFKdvkdB8YgVJYbGATj96Vl2JVy5oC+jcN6nNjGtMFhKYuogRIMh+T9C+CRCYMPfWbREF7iftTPrV03O+Vef77WND/pD9eM0sRRcvmBMw2kCWSQEzngKKTQFJigjJwfBM0P1XkBr341Y+YwpMqRoe7cjnLzQlAt2NjPyDNYxTk4abbl9rT2rZ7wmIklWjsWLWDz5jWOFGEosARkdLNS6XI8P0ACa/iKUoO8u2yyazdh/sGIGYkr6IUl2Nr97cFO7PbZ5cMfR633ki8c51+FiJmgX28Ah1tj9gUsOHFe7vp7DdUJDHMRZuo+UqwXPsNCXDpUaC/da9WHLJX9Eg8ZJOh26ILJML50UpIc2eb3ydDl5ueJ5pdyto+G0Vj7U7zSjl0QpMFrmWS/2EjRgb004P2kYRqENd25VTS3thak6E5GpXj72PS5DRuRgk/Q3usG9fRGXdQi9Pos/lPDZeALoWTxTNMSSqIFoXLurWkO89zPqjOT9ENISCcdPakW3A9RxbTKc7KirkO+z9rQUXFBasbU5tshp6Ynir7pVDe68Pf8Qor7hEG9+joxH8a3urW/JrjHv9KfqLZrJba2WgRpGJjsZp8CIkiiIbuHBaf1qMrlSFTi8CuSzGIvax/h9dc2yGLqCop6WEbZhei+O5vluyYj+lT0xaQVetBy+Dk5x+26KfIutyC1Ls5I1x4LyFe4/PwowXZSlZk8WJgZ4zRga+XvmobRuzwhyIV59gNW6GpZ8Mn+aDLWEGzy3pQ84cm28HnSBVlbl4/K9MsxJ+1xv3UJSXsOK9LKXnxktrREnWt78Vu+Dc76MzjntoCrAxwEJ8dltsXv+8t+aWBIzsklEy0WX4kywfG4IaGOgMAyLwWFXtS1Zg7eG31jDxXIPoCC/K6dbeUEqnQ8ZJXlL/AmLRTlh2OCzHBgvQGgyeXCCjLPUo+jsAC5/p9gKWhxQ634WBtIDQ9zYO7cFKCpE2FbSh7aUXPGTwDBoi34zv3CwuCu5wRtu/VdRIPDTpZvOXsDLfqkmhPoFw7D1itd6dRVYQXoiP3IFUZfHNB6DAkPAPTsLHzMAypQaD+7tFpVuyxVkjpQ24g/o8o9zOGds3D4nc6WF0QLnKlCszTvL2+YSpAaoDdiUyxG+WGBhnvRedGT2wGJBRuEjRYF910RkM0bNhF+5bydkrt4TrjIxeCioQVbRldWZpUMiwhf2WM4RVtB/yRk/v5tXNkiUrXYQ+t9eqI2xMla3XrYVEKuKkJwiMX4bBB/FNmY2pPvYqdJlmG4GzTYSQtH518QuVDyIgnWsVHmGyc9zmEzvHTd37PgRypTe6CbhgAuSvQzKjroWfwKib1L5HBrzRqEUSj0XCN3ee3kxRlYr/yxjEUeriQTjLfzbYfOtkKKg9J4tim1GUCYbMQCCoowCqDgoeOiIp8gMiW+a91pDCu9ouhhUFxF3IM0GRQId1N+a9r4p8AQQuTRCKLm5PeM+jGMLcLroLMwSsEoduFThH/POrI+dLjao39Ynma5l9+TWuEB1LVxHUWt+MJBD+RQYgGgYE3ZF0oUfA3T1sxoFZ5UO+7Fx3BRQBpJVYmPJ1t0j2/S85Ce6gH2cGsmp7kOPTgNNB1TvklttPGRnlq+aeFHTMFLSWovwFmhFbZqNVFitrg0xPXpdfCOlKNlgcsKZSacHovL5xUHrG2klVZF862zbGQqeZGS7sHzRuzqIboYn7nLHMte2CkSjFt+yyrN6M1EXBQ+ak0Oc6vCgFNp8++sywK6LSjZ96sQGDbZfWJcja/low5OCMHf4IqKLk1LWrCEeYPxqd/Xu7X2T1/gYc59ddyvxjKi3cOSZOv4C6xjR7wiMXAPMgiE0xD/ibB+N+WMrpj4odkTuN898YRaNW2wJT2b0LZHS9DjckJsU0837JqdhtHHt1z7dpDqpPphUMYMvTQiakNfXSOiiHvle0zGjjnFPQXtkEUvd0fNArq9ldev1lBY7mgmkzbNY8A5CxuNo7lP2QlWI0B/PDf6Bx8/tawH/RL0oSjIXGHzoWN4/n75CF+zx4gDg6vPx7p1JLVBfhRhQQgJybTkhhSPiHBK2qgnGB86fe8/bT17m0bwTr31fKB9p2vhF4Ci7ExuaJWz32f25mhQL5S71Hx2b2HTpz0YMMuMjdhDHafXZnA0ykjnh/qKM7rRyjoccBryBtHTPegfQRbKl2Kle5yE6RJcahKUhkEMJizOSrqPCcreYBxR7poRTgJpaNl57+6rYgHCANKkZ4uw2ebqctFWuNpBm/1OP7dQKXOAi1X7bUtahhDL2GdJX9Mnp5mhRKXksvfmJZtbhq0XLVhw9u8vvTv9xLyTKMVPz58mtprCiJuT6PnELgCUYLX7p625H1Bh/ahBmp3LoCmMNMKbbOMlc3A3N6TWHbAEUp/AXtZDlH2AgXFfHebZ++xP9KYXfjPQtwMgZmmwbnmLOsKtR2vF1VEHtkShGIZy+NLZZePMbtrhd0xlENu3ixG7YP8qrSDZMQIj67i9Nk7GvSG2hSzRZvFu4i9t5x0Y9Vw6cLCphtojWwztodFW9auXwGejIISY+b2A1Jw7OahM4ZX9k2FaBBudFzeT5sV6obYPTvsdKLfLG6gfFmjuAPBSVXJD3uJQE5rkP3WdgaLU/yDTZelOR3gDGCL3eCadl2o6adPuaD+HB6JASIL1lRr8DZTyWhaz31WSF6jYMPysDIT9ed2fIb/e79Dv0+0CdqhhJd8e20a+fwof1iIfGQLxxYHz/z+vQGwx4Blw6twf6and7EApptXnL/eShtywk4aapLhGiYayTDtxm0iL7zR03tPpLwOBp7PQH83fk9RXZfAgAt60KZkmVWs0TJjrQlEiwAK7S+8bgufqFC/25dn8q58fnPGYuf2SBYE7M0LU4PUMJBEXhS9U9zItyMUpydn9MmkGF5qx48Z39m+5EAYsL5ULZf8lgQE7nHWEHC9JM1uHrZjYjYfvqnJ6imyPCJIpmay+rcRTH+4xbDV3Ia+Iwzzy9HOit2N67YI7Psiji6djYuE4016/6CkGhx322DDHdalNxG+Fex3nbr2EzCS4WGOlvq+3mM6GMqR0qFT+j5nS/oJmlfHoYIS3jF6Yezd6AJAi5Ppjz7gBwI6i1Vtp0frz/ueh3b/xJEhQWT35Smep7h0kVzxPFRd2Ag/hCaeM8gY8fxCGAfotkezgCX4x//aHpduRjtlNJ18KZo3sZc2JbZ5b6QG1exeCvnccP+7QLLN+9T+07sAjxw4We/2SSwCiComwSYt6fIw4E5usrdt1zc3r5dzdb5BjQ+aFLAbk7c4f9rk9DYlb8KGTzDzfHYFSm+pNmr7u1LlUH+izeVFhphl1Z2XrTlyHUqZDD2igz9UEEcBLV/IgpCgWch+hgj2mL6VavbEyWquW/68feDr4QasgXW2AbLZfkLr/ZxkEeKcAPHJDvwmiBRLT7E6M+OfrS0d9eUSC66yJfqs+w/5ODkGr7MIUJIBRyCeKZ/nG/dIjL7ngR1htuSNMtM8ZRTEfEcO5lzckaajNRk+8iR/ZqZYvbnmMsSMtvtyiHbPoq7sQWeA7Hp1+tIv7nNnnHDNp+eAfQPjjZBFeS+Eug/+TigzGuABw8LwPuTpugkXzNZ/Wk/vSspRNs0BJN0k8NY9C0b+eBZ7DtCZSaMUN5SPx9Z49uBCYd5GIocu5gbMhNmspbsgx6LOR3zZGF6+Xa1I/YfT+w/2qRjQByhQFqTsd0FMIFjxDFrzVxBBfjpdqU/teV3O8jWcqjQRVFoAcsagIIW/PFV1YjtHzmeOxu7KsV7oU+BKsT0C3XoQlkx98sYg/IfQuzCVPFu6uTQbjn8UpFa7RgTF2rHVHun1HCrPpRammYgV4BFgpdpl14fpAOIlCICBcT9s5gyiUp9JSHlCEHDGlK30rVHibMN3tzRT/U5ZsDLMqSCj2mweI1g/VMBRMx5yTXLCjwjCubjnD+eJHbHlPC2r9VXZ5Wrnw3Caf3FI5VrxE2wPv+htGH7MGqUuX2EGv76CNuaZHgFLP3gOtEgKgnRWR2RGoh1CSmS4/Wj9CKx5YNAgy/3LEroucDuphKHppYtBs3R6QD5peQYqAHOOWLoUtHbaTUTsO69dPmzC6MBXs1d++kxncv4bdnA1qxbiNwAalYgD0UfLcSKhEWOpc26cGeS6TlJmiTordVBlOIdy/32dFTe2BwWWXsCPX72f3+Y8R+WNUG4gFs/+dds3drLglkCLFs0h2OVpryJETbbU5V0pyo9USdb2KiGiHoneMid8xiRNrmP6i6BCY1n1j29POWL9VBSePuEy4HBf4xCPNFX3aMz3Tjyc9qK9/wadv/wSFniVk9UKoPtslzlz7Isxr62qwQft6DOllJ9vq3zhiQEY+YgDfurzBRgmJ1CQFlCAwGR7G/A5ZwkyJ8lnEgPdCHT8S4OV3W7tvJlPUWvI8VcJEBXX0saFW8ycNrjAqprhpGxLmP+ZifQfF+CGeiKJwo40C1YVe400XusXvf+5DdjX8Pk0Hm+NpJ9HHByoQGkatrPckevJT8bYJ3ewPMqzx00dsIylajqkLutcxUJsCpx1vaTwWBbdPSxTAC71TFoZ5puXn2HtyeKyUoNOBDqRQaBH8QsXTJMON6teHdvOW7vO9N/FcOe3cjPwj5poYMEzhtMu37FPl3x+OBzjbGceJXPgBLQjPd84NAZRCjYgtU3ZcHejjYv0UXYOxjilzrqP7wu5Ip6qh38BdjrnInl7KBVfgVNMX9ZPlI/hvXs/yrhElEoNmm31WEGvb69PH905bx94qqhSztrdPUc6ApYmHH88eHWUZhskpDNQAjSn+qox9AaKDTsHa7DwSQA7ZlwruFJpgV/13vdel109XXROfbwq8252eHWRlAA0hOP2vIijJ4LpF5D1gphLccHf0HOHgwyAVQ5/FLG4xvZI7mdoiLceJ6FvGnLgGZxilwqi+WubuJ9YLxNyedmAWueVPIJJYNLpnfKwM435su29uPvgiwGCcvHlDMkw4ZJt5Xg5RW6UxXdHJazfBqvFaj4RczLb7TyicPC2TTkMk60wL63OgijsFqjFKaLUGDT7HRlpmKWSHnuiGKKW5en9kDy3Rr8H/BtgzCCHyMYdH3WCkfD1NGlGVvr6yraM+/fQuYPjNyagGoUwzBfQ3tsPMBqMgsLts+kV8lT0dXRcWCB+qpucfOZMdWuIdv//sT1t6cajcmo+wi7f2qg0ut3/Z7AkTK4GexvQZPeDv+mAe0LQmADE5KDxzDg1oYKfqUzWUCmXA/efChr6KggtqqWqQGo3vc4KFfGMnh1ZVNYQ3UWBEnWdaHmTX1Hm9OUOQLQvj5y8r29/H+CHE4tg137VbEv2u/gvWvK5ilk1uwgwAFvNSTTpf0nZi9BGSV9iEoXbhm2MIEcO3nDC1h4hLaLb7MO9+dQ69v5V6yDi9RabvwRbeOgIqqXTKmpislD4e6oi+fvRB9lJ19QhkD55qke7XXMzLdGayeaPI0YIuqj9cLpEjQjrLxpZOziHa46MnYQOjZq9UFg859diYr1WOKVlv4ZTDNsyLxSQb7pmwQGhnXHsZcJKzyLRZCwvLkyKIDvY78OdyRlrUin0vmBm0Zf6WGA/lnXVO+EdGjeTUtXJL+uJW0XQ3RqOIlWp88H41pAIs4OvYTHpR2gnyeQhwowM5fundyzSHHqSMYHi5bUDiycNyNmTzuYttMDjX6A3tCnRBYx/U/PbmeYDIZ8ZBR4LviD4DdyQ8cqq2QHiy6J2UE9i3rxtFJlPiOlTrDHD2r6932xmFiF8UZgBqZuAJLckkppdJcONThg5LGEvy1Q6A8xgDpOpQWP5xPUDL9/+iDUb4E73ifNwR0CCTIJfFSnYkzGtX0I2W0y54S40Jh3PbRc6pRfETZnLZDtmpU+PnJWypMZjAWlsNRMHSiO4EtFc7EBeHKSM4LRKmlW7jJM/B0TsyEYXTFnuVsnsH7eLF0mSQht5RJMVNfSC8YKmYO0AqGL7jw8I7ht4Pawh1LM43112WI35hu6agMi06o6I1JFDjgqRxaMxXuCxWIeTcOc3uSlIIn/wx3NryJkRRkXZE0sJyb2Mj63P7ocKxuySpXDZoG85pPFwPBENKwkcVkm7XqtiGifp++p9U513eCDxa4zYEc2TJOE2ycNQxSDam5P9QhN1FCoCxTeYg60wq2q59tDLe6hVX8q2WKCciJCRpMSlwZB/B7Pl128sU7NufwxrnkyNN/F+rw3EEdxK/cINLXb3fRj580qNYvq91yqvRA9ODoLFQBWuaRanyWdg4OwJuVQP6A7EbcNoFr+fggx0cCy90WOe37XKDp2dagOpD8cdIvTAc21CLhbM5gv7OZMhj1ia3dwDgkWLwMTZQKQAK5Oy0Kho3fi308NK0TTHwT6feSxDNEwzDq4T213KWfDecCt2hkH5noR8Do15wo8DOHIxMVQIxoS37+sO3PNRhLbzc6z8lJE0sWeAwPgKcwcsV5MNH8JxgP+UI2HmBWDyU7Z4GqgDpCnkbRYQMJvuWdkpN+vKSAWJTNM18AHo5Q8OqdCsP7Oix1NyLNgSP8xwfzjJYMEvCoPzz4jIAeqzrL3utZgA9g9CxoFV1nTLQ7tC/xnz9ZMaoy4knrflBYip7SE8hOHOs4cB8GQsfaGnW8uIrFjuSk2n5TsOrl5lMzRx+1DSOBrTubzyTLGFYJUs91As0c0xCq6HPqbH/TeM7JKMIrX8BlwpvqedntNGgq8npxySfLddBmIEnpJIdu1JeArATo9Q80JLfeRJ7Izy7RpFGN6kuyXvoVEaCmMVkllCNYN7OMB4ZvX93YkH+Nyp4RVIm/yI9LL9odHdK8f6PBK+ckOaUDF284Oz+Zdw/lnMMqHYW5Sj1cBD6I/X4RjNNkbcHn4PlP/83nNJKwjW8eMWT6/C8qQVJIXZKtLm75d8XX8m42dYqILwSuYv4jkn1Lh7x8GEi0jjnePKhf/4pJseAZcswwJGA37tRuCWGXkSjRbtQdL6g6RA40O6+opG8g1T7ci9A5TQpoxfXiPzlv65wa+uLuWRp1jY/ZalirUn7zbcAYQrbTm3VGU/6qeuDyjrowtyxQYtV120qaVHnXveweiarAd/W9VPazK62lRCHNUkhTu4jGpdXTWnveAwx1K3qIvb2wjzX2BlCYifMFFsQLWDUEzoLQXpFwvbZJ5ilL6BuvYTKA0oQ0ftL8WEOZQr7k5qhBp1fyWKS6tdn0PO7JtsVSbcjMf2iDktbCBrUnjlmfy77AwfY8GxeGHs4QeCKP2iPtfm4KxQzyEITsbRx3W/t4l9Rq0G4cFef1uqld0DFtlJyNc9Nyxk+cBcicT7UIRI/iN9pIe0EBfpotEXhIzIUKIuS5vkWNxNqAJJHwENkue6OL3+8x093Olau1x2/KAdOHrsSN8R3tQElU1dtPxWDj8JW/SByfxlDLl1/REj8hDNbSH+3FhvR8ORKc/24HtR3Z7Rb7fxZJuZ0uMeHn7u1qV60NutxjVnca4lsJXkXkl/bFAaNAwzRcqkPQrvW8jULKRt4bAmqwRlrxUDVQO7uXVN0S83+n0dpLtP7QcQe4u7BoqO0pHkUYK5bEmvqjnG3o7CdcCQ12dO++gA1BAATjO7/Rrb1JYmX3BKH0n/gq3nvLvj7fvuxHxrLOLO+waXsdPDw3KcWP+pAnF+o6gxDh041z9SjeVYHVoZdzzbIcR8Mzpqhjo0Kz1h4WLmmvaaFLlyTw/7gLJPucf1TAQ6xma4w9EbxRFel5kj6v/fdw8XBkLuNPMJjWtjBeHqSEF3b9cPwogf6YdGmZ+f6tBEulqpWiT6TBHWh+q2tPW8cRDa3WH6iRc02AhBR4Sz/Uz4gZiuzgmntbKw1hsq87ppbB7KNBreyz0bLS6V0zV7aQxHzapbR6JqPmcKpc8dUO6PryNwtYwErh+0KmaeumT4PXKA0GqsD0KDxBZ1048T608A/XkoNssY7BsihcWWcgRLHB38HztYYfFrRZRlPm9ccMZJs3ErslfhiclvzZQDfBKUBaLq7u9RxCtm1qlIGEfTvjPm043j2FyX9RFX1BBSkY+nKtn6GfK8TVW9ezc3YNBgziwibu3PQQ1ysrqUv2J1/ge4pc2YXbKriv9WeOJKrxbbi5qMewtAqKc8aCnxvi69sbfNfR9NMDDM0UaBlwae+YwiDyaMiZXKRGSv0pVtveVEKwVGlPZVopCuvS+RZdXQScWrtlaTNqfSd4Ertn/oeV2gToX03IYhVBOeB075uPRguL7N/7NkShqpU8xz7ZCgMQLyeon2wUkOpkd9q6p+s4eAHK09eV1ywFldTEQlWEGSRDo+qQhwsvZ/BxxnUiOzsYql8uuk+pFl7oMZdCpK1tepg+46sPC7uvc/wCVkVMIAdYDIyVpEx31eltUriW0AciFD7VGI6MqDB43zAu4oL0d+TXt3k9uogL05jWstB9rYanJ7mojK4lVcZ25NF0pUHMxuIJ57H33X1MnEMVjrjN31odlQ4282uOqvk6yDwBN4WKE7/SKGxAjCsVJIRsKG8dWGxHpa3+9oIybcVG8BrusQwXSnxaXSfkERn/b9PdykTzkZSnXFrO9R2oHDSEZTMtkvhWFebiR8c8+0JtauzBDax3eNnxBN1h6RSLpHooJbKsSpda68T2o9p3onn056szInKcFyVB8DphVswDdo3d+UIo+A35rTlz8FQENejqUa6Y/rhX/e2VUmNlJIrSJo5+7N/4jX231+eHlCQr/kEGwtpbUnC/3BEDSNh4SnGiMxL2e3mtpdJHoZMX2D/o+VJuWeXBLJ86WCsND/BKAjmVLKm3rHDFAjNlJz/xed7WNWq/poxLE2D98PTw32TkygSpuKp3hIj7if2Zxi8CzrQwOPX4JFgifueOJZ713Pqt8pNhnzZhRa4nTwlDjEQ//lRygfA9LHxdt6yjPy4HBiojDZWvvQpb5+ra1U9g+ZCrbCcpLAERT5FkKkv26ZFMGS5j1bhyIrD9qJz5r/ynu1gqKFRyOV4Bje44HMQZa9hRcpBd2cOyrsnoBVcewU1QuqkQ2K+8/bfJJRGgsdKDNgw3c0O+Cc4iC4nPwkSi2niJrz1Xt1Tc52bu7wtOIugw6W0QFSNNnHB2c6KS1foeGx+oN9XL0AxG5vRp3e/qie6peFbJ9njAtfAuMbC8b09hGCKhKswYY4k1jY2nBw6LhxvImi1+T7xydwEMSHr9DRi4T0eI0nzHJ+Tc4czsl/pduuCzNZ1OAl5z/rmLYbj6g/6xpjZ9rg5Jl5GrJqCNJ8bWP2oiNC0q4wW5KocYVZIaZGsuEL2LOGOr5FhF7cv4scaI1Kl7qM9j1in1LNQKhCN87/CSQLscBcKS84zE5ZQ/SnChwh5bNYQjc2vuuSgCEeaH0xKx4U4RWj4QzaUaMtVr584GBmqyE16/XOE63FEu9tcYPU3+1y0E2COOmGGclcLQJHPsGH5y5NB8pjSrdpPJVLWdUmRzdKU1SLtWeGk4pHwEmHMyQtsXvPJNOAR7mC+4HlT/rlviTsZ/wj8j+uG68M9Yg3QYlUCpnBezTXx7DBojtoTDOIt3B+bxpBkafo312K3Y4wHmfufnEFWpSHAKbDLZ2q01bENK+8V/zedrffqNG2HpLGGApZMqkYWJY239k6iXZ/ny2UnAYadnu8vi5wWWklJvtNecmPGGPdwCrqvAyn615CnICQ/psvC6Fq1cElN8llSkww/rQe0xACg/qD5CRK5dD4sh4h3VAlhXQZT4HZ+1+89diLpLgCw89IdIQtX3vu38Aw/DWdhfUjGLyAHl/+rFkQdSKOUB2QohdfnjdQ4qO5o2DKEi4tytgMyoPhBfKpQw9SWHWKJwjJrF6OBMAjgaWqXLKB7flKQ2rZq9fMDkrwpwuOWFUG8xapzZIygP0K1HRZ/ImR6FyeecAHdnv+Z34WFkI2tKsrI4MzyTEZyb7plSg14zWRVaYWeXw7Tr3/7ipdMH7SeWHC0H+wVnDPd2N+lJwurLye47HTfAP/PfuLntpYlWPGCDYKSjOoD0DmJnQNCofYdCncaIkZ73qKzaKmgA4TqWcDW2049vRdDA84HzQ9qaLE0aUbBfcj0l87CBLnKhn1jPQTZOxUvgrpvFsz/PN53L29wfEwEIgZh5GgUPcGkEdAP8rUW+urcy0A8qtGEoa5T+J4/HXGHpBJWK6u0YMbN1Qlwvt6qutE3MC9PSGBFMx/4/ZF/TKYtYf1c0qjA5TXpRTuRYauus+udfk8OScPDmgzzHJA+RGroUijxpAuwuu9k0z5OYMwGdOpM4X6qi6eT3MVbX4NrROcStgbRidCWC6yOS7Epq6PgVzIPFvbeRMG6uCDf5mh/iXPrDv6AQL/mdtPTmNCYdFILq0JSIIKmUaK853QZm2VTtuj2nUgdeamuHI61mJWw7j77EJGrHkSuJlqXVqDNjdgVdAj9rOcwRUlZP8dOJ4pYal5aefaPo5t57WG7oSub7guQkmJ3zbSL6R5qcmxWeO4iiJgtchRuQe4v/SNtosxYU3B55w5PW00vLz0UKeVTBBm8q9fDAvNBX9rSZuoECCgqyiMTewGczKgpzZiWjE+zS5WYQjP9+4S/hrJFg4zRY9nAWJKuu0zrvvmkofhxXQXM6ZZWvUyRSQdjHogxG5AI74ToSCYzHcrgSo4lOnkPzti1PPEu1SRLXuu4FF+YAXJX1wAs0jfb6qUCuYR5M20FQN7ZhdOIc7CyLFPeD/CuCFQFiPGFHIA7Qt7OWqxkxmT45DvY0IdrH41MR6cf3uEeYkV/NQA690CMPodmudbsYPYuvUU/pBUYZvAn1nLmg4G88ytuCJ3N6fuVRLlN9iQams9eCuiLH9valsIgTS+2xcS+uwx7ikbsF9jgT0ow1ArrV6BV4yE/L9JQ7Na+efc3/p3+AJfKHxqHZ84RhLHRTD0v1wqIDA5EU9JSo3NwmnVzTslavSf9t+Gg8PHmx6L0yYP8VaTpUyYe8GnMUWjDQsJRpDUyxtFJhelLuYlKJzD2YTzNHzgnAOs6s7qlfN36kGL9oTMMe7kgRZxeP5cRfjiJq1cioeJPDPeo8MvnvmSs0ZReEle1f9L0Z+IIWzUBaU8qyaLghqm/TxdkQT0l2AzEvb8+Y3Tx5rp56XY8oO1u3nm9MwcJ79jhauU61xmMPIezE1cq7lnXxsUqvlLWWkVku/zgH7pRt7FEZn1GU/HmCl+hYLD8l3LEKO5+wYXeNZsKCaLGOp53UtzoxY88Etqndw+c0qxbnGm8U9tR0PAnwxwEIVDR627iPKGwOY4c1oz3Rdvqc2gVUv6r4+CaeW6H5/YDiaCP/efSIW18J4OLFkNB2Hp4NUfTtqKTd9XZeJAxBaN6uiIEoGyei7DG0jgvZnIWZuunypbL61cy35Ota9PuwdWfFRjQc+gS2c19kL97QRduTuFr8vQyJHeAIrEStQudPL3Xwi88KsjbjZx7lxbg3GNK9/Q29eQMJdeEXAWNiytdl1gu103ZGipdSbeKOpCBpwDTVc1G9OTYFtlwGL++VVgvm9AT06Ec9/HB4WQbBYaFmLHQctbGhDpd6z3JTyYlCvN7gk0qtOwCscy4QYQEQN/J3G1hKFoklZMXmMoDhpwtoMznDipI4ZTTG38djPlOJBA1pncvPM1vvRgHRhlYMHJDA0uEfxjYEj9nP1u7et5NA0lh1zNyEDgL66glE6kKtRB930yKH2t1BrDu4OjPpFQ8e8itddAH47kw7fx/qCYrbmtqrm1Ky/al9GWOJ5IxVYZejq3zJ3S3xH80U0SucUYln3z9JSPia2eDQkDVpq2mxMH82dmSEDuPaTmuw0U6rr3ZEjPzjKnfm8dxHzptTtL9ldXKvSdFy4R7ukBd9Higg5p9FrjaHg/pz7P2lFtT+Be47oibGUTBe3YRyxpIJD1TrjyOrL4mA85RF2Eo0zDb4DocpRK7crBZZQVb8q98295sZTr4vB3zll2X9z4IZTR97t5v4lSbO3P8mZUdAEaKa8vSuxVxYzC+F2ISO5xIHYlwlgO9v0b1ltn8SRv07U+UQqBgJbVqPbkUOaYSSQVhe0Up4nemSpa82a8ejFx1nvL7YwA2Qk4SB0AhJENqYRiSbpB4SVFnVRCi0iFwiprFs9kOlSMPzBWMTn9NYi9+RbvgotmrnjXvLdlr6PTBEJ+05discRjaZE+ioEtSxtnBNdlhmY6YU5LNL0o6ybPW32rfHyvsJoNGfLJ+WxEP5D5DEkqwOFUNWMLnkiX5IfmQDS+PxsL6hvvGWI2Z5+Cu37U0Tr2y3qqPEXS+mRg9Y5U/odDifHVxB1GpZb/29h8Uba7CBbfUZPfQKLIKJKd/1JflrZdqNQaeGphalpaEDIx7+ZstJhq4VbdZXdjq9I4iqGYp21qEvF1s7XubnAp885ECoTMv2wJpEvqUJXP6RqaIauF8rPHSHF4DQjht7UY29ayQN81x8eAQRqWJuqF4b6KCyOE936y0B8tf4IbkIj9O/TkVravXgSOMjd23gCOLY3QW6Ywvi45bK4ucUUIvmTDsqEraT/eMCOBnyVK7TYQ3PNiQwxVhy1N8nqOnAfb8/e0c/cEg7G0uSL6ADesiaJGQu4HIoIvA6EriKpevwc7lV6QVN2Gqb4En6Lp21GVmBbHwigsszXEvbB+BjT0+wv5SewyJToB0GfVn2QxmR215zvjJBcPs2wFnZ2nIYByoVj+oPQ7dpx7orhn2FTvQJNr7rtfCBb5pg/xvtlk5w/ir1BemWAMFYEFowe54NsDX7jFuVS4GBtGypF9ayc1vB51PGDsxp1d4fZREF0IR5MWmtzE3yP2AiVQfGelpx2MM/zYa+gAw8O9uOM0q1X39343LpYqgX7R3sGRut/HVzvFtw6csaS1XB+sYxYPtsds+x5ve2YNV/8VOnkzEjSUniCnOg6RwbnFAMZgirLoEjdeAbUvB49aq41PJ4ETFYpUe9MD7DOtkJeafD1sPCGgCX2s34zcGs8qNy6ah3u5381TSbjpwlj+HmGkbnUiLv5D3JDFymRrjYEkjK1DEmJaKsawSoBKiA5iCMLlUubwYPmPQzqpUuEfpRD1AR7HLPuteIv9TboApdP2G6lr5baqdEP4y2HXHMkyFGw7zrNg5drg0CPYf4bhCAzxkFsK8KNJ7lynqY046kKLC0VEzNT252SE+b/WKi1nx9nPIl//3/WgwicoR99t6fsYr4355Yclgx4e5lTYTiaLgTciY+rs9/99W9wJCtexRBgDmE2efvaD3v31kCQ+2gocaOtDTeGR4F4JZ3PCQAedIU/mD+8JJ0/Vmm8ghNCiQU5mTZIeGSRFExMqv+9RaNXmOOLAf98vET0zVlByk/PJ0+oZxHDpxMc/G0+SBs9dDqji3uUPr1EBcLxmESqcoki/N2iPxcIeRUVkdd2x8oRbSnzw2s8KlPkeXM7tc/7Yg7XaJg1voFLd6U0Ne4n4/10qRDprJL/2z6kEd09dL5l92Cw+cCw5AzuQ9bkHjMBklSNZjx5ydtWse1pJe7hHvSAJgqli1jcLUfJ3xNkjpAdd+OIvsnj0eVK7Ycb1v9lokgFm4CueesjGKiiAR2h0iwr6Kg6SxTEtibq+d2fZlIZP1U7qohklfefHL89VzTlgo2574kDRxjmMFYGfeeUV79FTqS+F2SS11Ermi46LvjrtPADyrNEZybeaxzEvA1DJdsb/aFbtkBp8wh+8vdzQ88JsLC1cv3shx0WOtpwEHsWhupD5KARN3ucc/hBeHYnTGpFvbWP+5GZqElGHYvSqY3PAQLdkNbNpmg10t3cnHr0bFEmEu6Hzpt5pdisWfEGyG9KqSXsqcP/H7jrdQFmj7EapPvd6iFn5ICnP7eu4ti17oR4Bvrh7zvC1/pFrnG7a6PwFKA2NjFiSawJL/NSSI1TYsilD8jpd1vSaSC403Ca5VAmApbs1e2lJJ0j81UJ1Cw4d23H4UJDJbf0P25DRAa8ZXAJf516Nq5c7xZG8oA9xmED6Z9kAC8xBDvkzbmurjmYY4gIdLnvjHyegMmbSdxXI5+pAgt/+huOsGYhSmL+/a3qhkNNrb6/gDXFFvRZXfLlAwmGT3mezT77nHedoaBew4DleQ4FFfCN0BMbvVPi3eH8MZ9YZ7TMQHg9Kt/LwS/463Ps6DQb+aKq402AmFF+dT8TtFGBbra7hcZlOww34HIW5YFPwxEROXcyfCtPJrpHZOepnwmwMNf5JVoOdJi8e9+bHxINk5fbLrLLj6FVZEu0wx8F3EHikx9BUgLz8+7CUBl0dwwtQ73gC+HwrsPYHWEo7OhONDxOKQ4E4UE28A7r3Blq/GHNrGGe3qpwZZkYw5MQFnO4mh7wOrSNh9x/YbWjT9aF2M5ybIH60/e4OegDv83djsGDI6d5Epg2IUtIBZ1LQMmv1nwZCC3/32W4lSrNNzu7a5L9QDKPAeTSTNIMhFfiB369WMeHvOzqdisMSOvQQoBAlOPswA7PWtk7oQ6n99YLLE+X8J2LISOhgi1D4HrNuihagPYqP/mFz23TYJOdkcQgrLIIImnkj7+3FLG2LnoGxubQbn7b8SQSuOrEb4JsNXSICwR95o6mecf50tTawCYL0trfKokdNVgpVzM41nr1OKEtKUxL8Y/dyk/oMr+48Zs1nX7IAmLXr067CoOay2bXYCMubgszPfGWE9CkMAaV1jK57ozFDFpE0zKUYLmDoSbkAjZzWpTm1gE2CXM+WrNC906Ae7lytDtgf1Q/Sl6VNS4uwqwBe9+hp0DaJezJVJBPGha9k8ukKEXJzgpYY0TR9l/a7iYtGc0iYTsuYdBXHC94NFuyV3c0zewnxJS8R/FVrBTocbPWhjO/fP9JU0uhVhXL9HiBHQo+TNFa4JKc2fT02boSciWk8YbZbN6QdJIEG9KUSAXQMKdqQZ79jxP1Wik6YN45ykH5pVuFcE4rsXfZFgyCFdEtPRDhM8mtXOEq43ovuAf02hqQrEDeUPfdqUQm4eNwo09FngvEIxApAEJqftSSBGJVxYO8TVRuZNXxkAmXImAx8k5EpeO43SljqLNX59OV8I2NMJRCQ42JQoVPLZaIn7XKCHFfQd+WhTQg1US14Ktx8BMYiPSg4V6/GoIGgpMPDKCPu2Q7f2xu60tIhlQRwEx3mrnBlbXsEWJEbhV6t3wxaltIEf29MHba48T3R3AmVrMIOrG8cPjF5O+ngt93SJd0jJXq5nl87hr4O/QruA/DA8iMUMY3mW2PWrBrMEBWJSbWHr0DGHSdAnh8n2WXJQT/Vftoaf9iFtZez3GsEMTzAeVto7o+FWaKB4zAbc0BSHtburg5eRxd9CAQFwZnOt6McRk7eolSETUCr4AwO6MY8+t7qSkRc+XabUqFxRwD47EkLJpnvxWq708S14n3+bcYN0/14/LZXTo4DcKjg7jJSaHFmVhbuk6LmCPi2WyuewWaU06N9mlLOcMqPEwFnM/Ze6+zh1Q4VmTzdNNW/FAN+wmeILHDLK5ZVKXDEhHXoZNzkAaFbeXXaFJiQWp6t6J7MaRMfm/0Z7NxNpG5TeUgCaTrQ6TWRpPae65BAKX2v5T3/y7aErIIw7lPmbHhDJjRKwVxNRu+3FpCXXoY9aqXix8GOaKWVi1rcSQPSpXwA9PO1Ekjkkkm+N9vBOJij7Fm8JZFjZjcfbzisD1LCqD7nCFaGz1PqHUHWZIwv0VTsuOJ/iKnukXOiIOquIckLbr631f4t0TAi20ox9O0lc/P1eIT+C7RoiTjz5i/1xPyZ2j5xaB+gqPlnWLlJL1Ohe83ZiC8Nu78TBCnc/OtZVXCji+07nub+TVgXHukYNOSyapg4D/m55S6cCnr4V1Javx90KtLGSvzNxj1l723gQN4vLFL56gDoVxNtkoeRvvNA13iZMYgfywpUgKVYaju9brmXf3vvtJq+EwStEEz1RkRxmVyiANIlmnn3DNJdUKItmgry8FN2Vtxk9UFcpvOfmra+5uKctezPn9C6qkkNHYoe7M1DvqezolSA/JjxDzYZh7C5ay74ZC52lZG10FDcEBDCbdRthbOT4SrpaEWbK70IrT2emDRJOJmRnKzPB9ImQ818vRjTjKFAfesubfyWhpmuuhXPB52XScBNAiUVR6c9VGR8L9hdpW0eQaiCey55uygtF4Ypquct0jO2C/esuG5VERxEqyGEAfbOgcTIZ2O7k1AZBd026VAIimbd88mKFOqF/4dgAHFIQdmbhAFVhG8LGb152ZapuK/ZJdZsOO7Np4POgHMRrFkiDhCzAKWDfnnv6YVq39tVNUbve3oGJPV98UDS9f9s93lCmb+KY/a4SQigN8fApa8YDb1MVvlxiei3uRIT8zSZpnAYcIoKJYoH+mJ2NH0S8ZIDEpcvrqdauuflzNaXUNC1FICh/zXz3A8P290UwlQ0L33rWjM4kuGgkKwB4E35djfM1wgRguqgRGssO28CkGBYRibgCnaD54UxxZr2ilnFIk0eNdakU3suo7WaUOuVvmPJDindKqlMGcYpGNvBAJxX019BHZGneY21seH+3bHfaZCj3tpFmYL1890yN1m0ERTNvamKaMm0o7UnPczSJdLZYHIWaCuuQnMssskX1zRd8RM57Do6NE9J4OmakOp5Ackm1XLPE7tAbl2YvNTuQ6il7/CmkPEEFXigcKL1368B2bEGGJrKNCkn5HbEwF8SfcP9etdnne7U1xRdOlKS/A2TwDq9eRfgNa5qKH9OvTxfw1e+3sRmAZ8LDHeiuQonDnnEw6mDoxeFNJqCAcngMb7igxM688my7Xl1u7qQB4sgLiZoPyFBK5kXKOwG87OA3NCdzeNaIS8/c6qoASegm2irDchAZWBCfnxWn5PevaFhxniD2/cp5Vcxe3hGkF0mIoMsbcsA0+kZL1aU7PHqWjjE0YetuWbRugjczw7/r85JnlmPfIY+bMvTCyQXuEtJ683FH4TNNaPHJOW8iUHBXvYqWUfiER9fyagQTLnQ7ykT9NdTU91kPz2Ixw2LU4GwYHPN0M6xqlsVxcPaOukFnitmcT5CuFYniATgci81xb8CreRgoiG+i8hSq88AqLyx8Ay5Z/QtMyqMiuGJtcvmYOxGzIpMXoJ7B8mMSNUyu2AJo1SbZOpudOlpqbo6j9wl8seI1hx4BsCaDqvHe4KxgcNoPhHLy2Wz7ErIFiTKKbKITwS92F2mFb+g7mEDxgY0UcfAF7Hb4we9cz507ECWaraGlInMdXVix5i1350ddfqm83Bdoo2dJSpiSf+sVqDeTESnGUuYOxhHoayM8UTDFzwEuvw5Et+rowl1ljBcM1Dag53jgL5pnMwWPQiaHkFMHUSuS+y2e3OLH+Sgk9rqZOH43vNTzn/Fnj5Q5d3AlUj1lzQQGK6eTc9ekktw+SvKMJ4mw4RGq/AUxhgl+tgTdwwv8LScH/enEFHCM5mNvLxQofDlur01XjJ05pBngwkYJJ0FjjYDnyrvlvcTFGRxBtS/YXVIxK4rj0suMkFrSJyYEfZxp4UJ1qop95oFhpPe1s8tibpqOPxHHXe67mA+fnxEi2/HpYWeCVNq/902a46yColYDu5bQyVU+adp7geqllnY+nsHdPQbbU1ryRbO9eXVvipMlV09wou73NiGLTs/EIKEgeV7ZGYsDlu4+JNCjurGQNYtoc/1A4gLDWcLnZ4BAW6nRSfZIIHk5qf1L17Jlr2GYfK047zBeu16luxssifdc5CscovrtJNVPrSO6OjClQJsBEWhMCo67DlL9k6VJuAnL90/EgqpNX3mDpgvPtKL5+b1edDmT6vB54g7wyFlDuPhzO++WS0ha2E3cOfXFlJ3RNVYtxWZdr9eYcI3mq480HiJH0Z8gouA60M4ENnpTb2bIC3Qymbh+kZJk0F83eFTLO5ztB5bnWiWJ7CNJLJZ1q8ZByl8ubsc6q3as9agK6uAimvigMTdlPP9gdkNueD0hhKQFdAc5He2N+INWpZJ01LhOMCIOp7elFMZA8pg0QTeF3V/S4zs8/y9ZS/KMuX8Iu/NYjKA5deQ/vxJOCDPFc3WNhiGu2PLZNJIgr1oGpANXLSSb7faYkiKI88fgJtQFyEfnLCF6v+0dbIQFuwPEF53XQdotCFJzGukG0axGQHiTidDYtoqze58IFUSSDzwBJIX6ry0F5YCs7ZGXsnnjacMY8Pdo5d+7Yb9XQoL30sB2TtPcBuySnMGIMxGRJNw8GxqOkf+mE18hl3ZJO7l7sDW8H6WOdnx+0dJr7BuI1abjWaqbxU5J6RI+pUd6m3cakUD+TF7GTW6d1SeHqjj7K/oAAIEzB64P1+/IefOMSOVr4jan896pITbAL4z9f+YXF4ha/yHWevl0lryjzI2ZZgF/A/pklcHPaOOYbWNN9gQdoQC2tLCAc1AxBMdG+PryTevnR2CjcMRQMgKWAY4KMlejp9fGAVS9LYdaVUQu9PgwF5vrBeV6TyToSdOQLH0cqCIB/UWO1pFFM311tqTxHHhz+gpqCN21LNBytUtxkAGPcvmmnSudV8zDCObVN+JZkMbjgNMrYIqIxeEvQhPR6QvSW5EFuKVQZQCnIjMZGqPiOKt1Kx4x0bW1T7Tfl7uXMK8TsxsqzuDy+arDPAclFwbAgFgBCYDuAAcLAQABIwMBAQVdABAAAAyBhgoB1pCeMAAA; VarID: ---
Type - Grafica - SymbolApiHeight: 0 m; SymbolApiWidth: 0 m; SymbolScale: 1; SymbolApiLength: 0.00084 m; SymbolHeight: 0.0008 m; SymbolLength: 0.00084 m; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod.R671
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod.R671; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Altro - Famiglia: LFX_I_IguzziniMod.R671: LFX_I_IguzziniMod.R671; Famiglia e tipo: LFX_I_IguzziniMod.R671: LFX_I_IguzziniMod.R671; ID tipo: LFX_I_IguzziniMod.R671: LFX_I_IguzziniMod.R671; Tipo: LFX_I_IguzziniMod.R671: LFX_I_IguzziniMod.R671
Elettrico - Circuiti - Dati elettrici: 0 V/1-10 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes
Name (LFX_I_IguzziniMod.R671:LFX_I_IguzziniMod.R671:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
8675611 | L00 - Piano Terra Piazza ELETTRICO | 4100 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675632 | L00 - Piano Terra Piazza ELETTRICO | 4101 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675655 | L00 - Piano Terra Piazza ELETTRICO | 4102 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675664 | L00 - Piano Terra Piazza ELETTRICO | 4103 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675688 | L00 - Piano Terra Piazza ELETTRICO | 4104 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675697 | L00 - Piano Terra Piazza ELETTRICO | 4105 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675729 | L00 - Piano Terra Piazza ELETTRICO | 4106 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675738 | L00 - Piano Terra Piazza ELETTRICO | 4107 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675814 | L00 - Piano Terra Piazza ELETTRICO | 4108 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675823 | L00 - Piano Terra Piazza ELETTRICO | 4109 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675846 | L00 - Piano Terra Piazza ELETTRICO | 4110 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8675855 | L00 - Piano Terra Piazza ELETTRICO | 4111 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8682081 | L00 - Piano Terra Piazza ELETTRICO | 4153 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8682119 | L00 - Piano Terra Piazza ELETTRICO | 4154 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8682130 | L00 - Piano Terra Piazza ELETTRICO | 4155 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8682141 | L00 - Piano Terra Piazza ELETTRICO | 4156 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8686923 | L00 - Piano Terra Piazza ELETTRICO | 4167 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
8686940 | L00 - Piano Terra Piazza ELETTRICO | 4168 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8686965 | L00 - Piano Terra Piazza ELETTRICO | 4169 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8686983 | L00 - Piano Terra Piazza ELETTRICO | 4170 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8687009 | L00 - Piano Terra Piazza ELETTRICO | 4171 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8687027 | L00 - Piano Terra Piazza ELETTRICO | 4172 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8687126 | L00 - Piano Terra Piazza ELETTRICO | 4173 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696029 | L00 - Piano Terra Piazza ELETTRICO | 4413 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696042 | L00 - Piano Terra Piazza ELETTRICO | 4414 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696051 | L00 - Piano Terra Piazza ELETTRICO | 4415 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696060 | L00 - Piano Terra Piazza ELETTRICO | 4416 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696073 | L00 - Piano Terra Piazza ELETTRICO | 4417 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696082 | L00 - Piano Terra Piazza ELETTRICO | 4418 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696167 | L00 - Piano Terra Piazza ELETTRICO | 4419 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696194 | L00 - Piano Terra Piazza ELETTRICO | 4422 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696207 | L00 - Piano Terra Piazza ELETTRICO | 4423 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696216 | L00 - Piano Terra Piazza ELETTRICO | 4424 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696237 | L00 - Piano Terra Piazza ELETTRICO | 4425 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8696246 | L00 - Piano Terra Piazza ELETTRICO | 4426 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697451 | L00 - Piano Terra Piazza ELETTRICO | 4475 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697496 | L00 - Piano Terra Piazza ELETTRICO | 4476 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697505 | L00 - Piano Terra Piazza ELETTRICO | 4477 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697518 | L00 - Piano Terra Piazza ELETTRICO | 4478 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697529 | L00 - Piano Terra Piazza ELETTRICO | 4479 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697540 | L00 - Piano Terra Piazza ELETTRICO | 4480 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697549 | L00 - Piano Terra Piazza ELETTRICO | 4481 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697558 | L00 - Piano Terra Piazza ELETTRICO | 4482 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697569 | L00 - Piano Terra Piazza ELETTRICO | 4483 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697578 | L00 - Piano Terra Piazza ELETTRICO | 4484 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697591 | L00 - Piano Terra Piazza ELETTRICO | 4485 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697602 | L00 - Piano Terra Piazza ELETTRICO | 4486 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697615 | L00 - Piano Terra Piazza ELETTRICO | 4487 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697626 | L00 - Piano Terra Piazza ELETTRICO | 4488 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697644 | L00 - Piano Terra Piazza ELETTRICO | 4490 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697675 | L00 - Piano Terra Piazza ELETTRICO | 4493 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697684 | L00 - Piano Terra Piazza ELETTRICO | 4494 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697693 | L00 - Piano Terra Piazza ELETTRICO | 4495 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8697702 | L00 - Piano Terra Piazza ELETTRICO | 4496 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8698814 | L00 - Piano Terra Piazza ELETTRICO | 4520 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698837 | L00 - Piano Terra Piazza ELETTRICO | 4521 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698856 | L00 - Piano Terra Piazza ELETTRICO | 4522 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698904 | L00 - Piano Terra Piazza ELETTRICO | 4523 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698915 | L00 - Piano Terra Piazza ELETTRICO | 4524 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698939 | L00 - Piano Terra Piazza ELETTRICO | 4525 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698948 | L00 - Piano Terra Piazza ELETTRICO | 4526 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698972 | L00 - Piano Terra Piazza ELETTRICO | 4527 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698981 | L00 - Piano Terra Piazza ELETTRICO | 4528 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8698990 | L00 - Piano Terra Piazza ELETTRICO | 4529 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8699425 | L00 - Piano Terra Piazza ELETTRICO | 4533 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8699447 | L00 - Piano Terra Piazza ELETTRICO | 4534 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8699470 | L00 - Piano Terra Piazza ELETTRICO | 4535 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706493 | L02 - Piano Secondo ELETTRICO | 4818 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706502 | L02 - Piano Secondo ELETTRICO | 4819 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706577 | L02 - Piano Secondo ELETTRICO | 4822 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706594 | L02 - Piano Secondo ELETTRICO | 4823 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706646 | L02 - Piano Secondo ELETTRICO | 4824 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706657 | L02 - Piano Secondo ELETTRICO | 4825 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706684 | L02 - Piano Secondo ELETTRICO | 4826 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8706693 | L02 - Piano Secondo ELETTRICO | 4827 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707622 | L02 - Piano Secondo ELETTRICO | 4857 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707639 | L02 - Piano Secondo ELETTRICO | 4858 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707656 | L02 - Piano Secondo ELETTRICO | 4859 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
8707677 | L02 - Piano Secondo ELETTRICO | 4860 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
