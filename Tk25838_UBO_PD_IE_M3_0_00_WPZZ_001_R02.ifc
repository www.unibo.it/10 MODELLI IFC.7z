Properties of the parts of a building model (IFC4), part 9 of 23

# IfcBuildingElementProxy: Rack:EEQ_I_Rack (11)
Name (Rack:...) | In | Contrassegno | Nome quadro | Livello | Host
RACK P2-A:9053990 | L02 - Piano Secondo ELETTRICO | 550 | RACK P2-A | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO
RACK PT-A:9070751 | L00 - Piano Terra Piazza ELETTRICO | 552 | RACK PT-A | Livello: L00 - Piano Terra Piazza ELETTRICO | Livello : L00 - Piano Terra Piazza ELETTRICO
RACK P1-C:9423007 | L00 - Piano Terra Piazza ELETTRICO | 603 | RACK P1-C | Livello: L01 - Piano Primo ELETTRICO | Livello : L01 - Piano Primo ELETTRICO
RACK P1-A:9423016 | L00 - Piano Terra Piazza ELETTRICO | 604 | RACK P1-A | Livello: L01 - Piano Primo ELETTRICO | Livello : L01 - Piano Primo ELETTRICO
RACK P2-B:9427259 | L02 - Piano Secondo ELETTRICO | 639 | RACK P2-B | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO
RACK LAB. I.:10301694 | L00 - Piano Terra Piazza ELETTRICO | 645 | RACK LAB. I. | Livello: L01 - Piano Primo ELETTRICO | Livello : L01 - Piano Primo ELETTRICO
CENTRO STELLA:10665997 | L00 - Piano Terra Piazza ELETTRICO | 663 | CENTRO STELLA | Livello: L00 - Piano Terra Piazza ELETTRICO | Livello : L00 - Piano Terra Piazza ELETTRICO
RACK PI-AR:10666004 | B01 - Piano Interrato ELETTRICO | 664 | RACK PI-AR | Livello: B01 - Piano Interrato ELETTRICO | Livello : B01 - Piano Interrato ELETTRICO

# IfcBuildingElementProxy: Rivelatore Volumetrico:DSE_I_RivelatoreVolumetrico (50)
Type - Classification: D5030800 Security & Detection Systems (Uniformat); Material: Plastic-Lutron-White-Gloss, Plastic-Lutron-Clear
Type - Altro - Categoria: Dispositivi di sicurezza; Nome famiglia: Rivelatore Volumetrico
Type - Costruzione - Coverage: 148.645 m2; Field of View: 110 deg
Type - Dati identità - CADworks URL: http://www.CADworks.net; Codice assieme: D5030800; Commenti sul tipo: SAI; Copyright: © 2010 Lutron Electronics Co., Inc.; Descrizione: Infrared Wall Mount Occupancy Sensor; Descrizione assieme: Security & Detection Systems; Modello: LOS-WIR-WH; Nome del tipo: DSE_I_RivelatoreVolumetrico; Numero OmniClass: 23.85.80.11.27; Product data url: https://bimobject.com/lutronelectronics/product/lutron-los-wir; Product URL: http://www.lutron.com/Products/Sensors/Occupancy-Vacancy/LOSWSeries/Pages/Overview.aspx; Produttore: Lutron Electronics; Series: LOS-W; Titolo OmniClass: Lighting Controls; URL: http://www.lutron.com
Type - Dimensioni - Nominal Depth: 0.0990203 m; Nominal Height: 0.162719 m; Nominal Width: 0.0914797 m
Type - Elettrico - Voltage Comments: 20-24VDC
Type - Materiali e finiture - Sensor Material: Plastic-Lutron-White-Gloss
Type - Vincoli - Height: 0.13335 m; Infrared Major Motion: 12.192 m; Infrared Minor Motion: 6.096 m; Prospetto di default: 2.2 m; Range Diagram Height: 3.6576 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DSE_I_RivelatoreVolumetrico
Type - Pset_EnvironmentalImpactIndicators - Reference: DSE_I_RivelatoreVolumetrico
Type - Pset_ManufacturerTypeInformation - Manufacturer: Lutron Electronics
Material: Plastic-Lutron-Clear, Plastic-Lutron-White-Gloss
Altro - Famiglia: Rivelatore Volumetrico: DSE_I_RivelatoreVolumetrico; Famiglia e tipo: Rivelatore Volumetrico: DSE_I_RivelatoreVolumetrico; ID tipo: Rivelatore Volumetrico: DSE_I_RivelatoreVolumetrico; Simbolo: Riv 1; Tipo: Rivelatore Volumetrico: DSE_I_RivelatoreVolumetrico
Dimensioni - Area: 111.877 m2; Volume: 0.000334998 m3
Fasi - Fase di creazione: Nuova costruzione
Grafica - Infrared Major Motion Detection: no; Infrared Minor Motion Detection: no
Vincoli - Quota altimetrica da livello: 2.9 m
Name (Rivelatore Volumetrico:DSE_I_RivelatoreVolumetrico:...) | In | Contrassegno | Livello = Livello abaco | Host
9658251 | L02 - Piano Secondo ELETTRICO | 378 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9658325 | L02 - Piano Secondo ELETTRICO | 379 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9658420 | L02 - Piano Secondo ELETTRICO | 381 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9658492 | L02 - Piano Secondo ELETTRICO | 382 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9658760 | L02 - Piano Secondo ELETTRICO | 383 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9658848 | L02 - Piano Secondo ELETTRICO | 384 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9658922 | L02 - Piano Secondo ELETTRICO | 385 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9659209 | L02 - Piano Secondo ELETTRICO | 386 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9659406 | L02 - Piano Secondo ELETTRICO | 387 | Livello: L02 - Piano Secondo ELETTRICO | Dati : DDA_I_DatiDoppia
9659427 | L02 - Piano Secondo ELETTRICO | 388 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9659573 | L02 - Piano Secondo ELETTRICO | 389 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9659662 | L02 - Piano Secondo ELETTRICO | 390 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9659788 | L02 - Piano Secondo ELETTRICO | 391 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9659974 | L02 - Piano Secondo ELETTRICO | 392 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9660302 | L02 - Piano Secondo ELETTRICO | 393 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9660445 | L02 - Piano Secondo ELETTRICO | 394 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9660451 | L02 - Piano Secondo ELETTRICO | 395 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9660547 | L02 - Piano Secondo ELETTRICO | 396 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9660579 | L02 - Piano Secondo ELETTRICO | 397 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9660673 | L02 - Piano Secondo ELETTRICO | 398 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9660978 | L02 - Piano Secondo ELETTRICO | 399 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9660998 | L02 - Piano Secondo ELETTRICO | 400 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9661022 | L02 - Piano Secondo ELETTRICO | 401 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9661109 | L02 - Piano Secondo ELETTRICO | 402 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9661168 | L02 - Piano Secondo ELETTRICO | 403 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9661409 | L02 - Piano Secondo ELETTRICO | 404 | Livello: L02 - Piano Secondo ELETTRICO | Dati : DDA_I_DatiDoppia
9661423 | L02 - Piano Secondo ELETTRICO | 405 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9661627 | L02 - Piano Secondo ELETTRICO | 406 | Livello: L02 - Piano Secondo ELETTRICO | Dati : DDA_I_DatiDoppia
9661701 | L02 - Piano Secondo ELETTRICO | 407 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664398 | L00 - Piano Terra Piazza ELETTRICO | 408 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664449 | L00 - Piano Terra Piazza ELETTRICO | 409 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664471 | L00 - Piano Terra Piazza ELETTRICO | 410 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664547 | L00 - Piano Terra Piazza ELETTRICO | 411 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664602 | L00 - Piano Terra Piazza ELETTRICO | 412 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664715 | L00 - Piano Terra Piazza ELETTRICO | 413 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664820 | L00 - Piano Terra Piazza ELETTRICO | 414 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664864 | L00 - Piano Terra Piazza ELETTRICO | 415 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9664932 | L00 - Piano Terra Piazza ELETTRICO | 416 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9665028 | L00 - Piano Terra Piazza ELETTRICO | 417 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9665073 | L00 - Piano Terra Piazza ELETTRICO | 418 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9665153 | L00 - Piano Terra Piazza ELETTRICO | 419 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9665278 | L00 - Piano Terra Piazza ELETTRICO | 420 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9665541 | L00 - Piano Terra Piazza ELETTRICO | 422 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9686327 | L00 - Piano Terra Piazza ELETTRICO | 450 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9686366 | L00 - Piano Terra Piazza ELETTRICO | 451 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9686439 | L00 - Piano Terra Piazza ELETTRICO | 452 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9686535 | L00 - Piano Terra Piazza ELETTRICO | 453 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9686629 | L00 - Piano Terra Piazza ELETTRICO | 454 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato>
9687045 | L00 - Piano Terra Piazza ELETTRICO | 457 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9689147 | L00 - Piano Terra Piazza ELETTRICO | 480 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Rivelatore di presenza:DLG_I_RivelatoreDiPresenza (249)
Type - Material: Infrarossi rivelatore di presenza
Type - Altro - Categoria: Dispositivi di illuminazione; Nome famiglia: Rivelatore di presenza; Simbolo: Riv 1
Type - Dati identità - Commenti sul tipo: Comandi; Nome del tipo: DLG_I_RivelatoreDiPresenza
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DLG_I_RivelatoreDiPresenza
Type - Pset_EnvironmentalImpactIndicators - Reference: DLG_I_RivelatoreDiPresenza
Material: Infrarossi rivelatore di presenza, Scatola rivelatore di presenza
Altro - Famiglia: Rivelatore di presenza: DLG_I_RivelatoreDiPresenza; Famiglia e tipo: Rivelatore di presenza: DLG_I_RivelatoreDiPresenza; ID tipo: Rivelatore di presenza: DLG_I_RivelatoreDiPresenza; Tipo: Rivelatore di presenza: DLG_I_RivelatoreDiPresenza
Dimensioni - Area: 113.196 m2; Volume: 0.565499 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Grafica - Copertura rivelatore presenza: no
Name (Rivelatore di presenza:DLG_I_RivelatoreDiPresenza:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9457587 | L00 - Piano Terra Piazza ELETTRICO | 573 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9457751 | L00 - Piano Terra Piazza ELETTRICO | 574 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9457766 | L00 - Piano Terra Piazza ELETTRICO | 575 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9466676 | L00 - Piano Terra Piazza ELETTRICO | 576 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9466693 | L00 - Piano Terra Piazza ELETTRICO | 577 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9466709 | L00 - Piano Terra Piazza ELETTRICO | 578 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9466723 | L00 - Piano Terra Piazza ELETTRICO | 579 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9466977 | L00 - Piano Terra Piazza ELETTRICO | 581 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467038 | L00 - Piano Terra Piazza ELETTRICO | 582 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467068 | L00 - Piano Terra Piazza ELETTRICO | 583 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467088 | L00 - Piano Terra Piazza ELETTRICO | 584 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467110 | L00 - Piano Terra Piazza ELETTRICO | 585 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467130 | L00 - Piano Terra Piazza ELETTRICO | 586 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467151 | L00 - Piano Terra Piazza ELETTRICO | 587 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467167 | L00 - Piano Terra Piazza ELETTRICO | 588 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467190 | L00 - Piano Terra Piazza ELETTRICO | 589 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467207 | L00 - Piano Terra Piazza ELETTRICO | 590 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467209 | L00 - Piano Terra Piazza ELETTRICO | 591 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467220 | L00 - Piano Terra Piazza ELETTRICO | 592 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467234 | L00 - Piano Terra Piazza ELETTRICO | 593 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467312 | L00 - Piano Terra Piazza ELETTRICO | 594 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467327 | L00 - Piano Terra Piazza ELETTRICO | 595 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467348 | L00 - Piano Terra Piazza ELETTRICO | 596 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467365 | L00 - Piano Terra Piazza ELETTRICO | 597 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467384 | L00 - Piano Terra Piazza ELETTRICO | 598 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467421 | L00 - Piano Terra Piazza ELETTRICO | 599 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467442 | L00 - Piano Terra Piazza ELETTRICO | 600 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467456 | L00 - Piano Terra Piazza ELETTRICO | 601 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467485 | L00 - Piano Terra Piazza ELETTRICO | 602 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467512 | L00 - Piano Terra Piazza ELETTRICO | 603 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467530 | L00 - Piano Terra Piazza ELETTRICO | 604 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467543 | L00 - Piano Terra Piazza ELETTRICO | 605 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467545 | L00 - Piano Terra Piazza ELETTRICO | 606 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467569 | L00 - Piano Terra Piazza ELETTRICO | 607 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467592 | L00 - Piano Terra Piazza ELETTRICO | 608 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467614 | L00 - Piano Terra Piazza ELETTRICO | 609 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467629 | L00 - Piano Terra Piazza ELETTRICO | 610 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9467706 | L00 - Piano Terra Piazza ELETTRICO | 611 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467724 | L00 - Piano Terra Piazza ELETTRICO | 612 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467743 | L00 - Piano Terra Piazza ELETTRICO | 613 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467757 | L00 - Piano Terra Piazza ELETTRICO | 614 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467773 | L00 - Piano Terra Piazza ELETTRICO | 615 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467786 | L00 - Piano Terra Piazza ELETTRICO | 616 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467801 | L00 - Piano Terra Piazza ELETTRICO | 617 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9467822 | L00 - Piano Terra Piazza ELETTRICO | 618 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 5.4
9468304 | L00 - Piano Terra Piazza ELETTRICO | 619 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 5.4
9468338 | L00 - Piano Terra Piazza ELETTRICO | 620 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9468354 | L00 - Piano Terra Piazza ELETTRICO | 621 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9468384 | L00 - Piano Terra Piazza ELETTRICO | 622 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9468956 | L00 - Piano Terra Piazza ELETTRICO | 623 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9469002 | L00 - Piano Terra Piazza ELETTRICO | 624 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9469035 | L00 - Piano Terra Piazza ELETTRICO | 625 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9469036 | L00 - Piano Terra Piazza ELETTRICO | 626 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9469046 | L00 - Piano Terra Piazza ELETTRICO | 627 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9469047 | L00 - Piano Terra Piazza ELETTRICO | 628 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9469063 | L00 - Piano Terra Piazza ELETTRICO | 629 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 5.24598
9469083 | L00 - Piano Terra Piazza ELETTRICO | 630 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 5.24598
9476456 | L00 - Piano Terra Piazza ELETTRICO | 632 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9476571 | L00 - Piano Terra Piazza ELETTRICO | 633 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9476590 | L00 - Piano Terra Piazza ELETTRICO | 634 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9476607 | L00 - Piano Terra Piazza ELETTRICO | 635 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9476627 | L00 - Piano Terra Piazza ELETTRICO | 636 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476644 | L00 - Piano Terra Piazza ELETTRICO | 637 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476665 | L00 - Piano Terra Piazza ELETTRICO | 638 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476683 | L00 - Piano Terra Piazza ELETTRICO | 639 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476708 | L00 - Piano Terra Piazza ELETTRICO | 640 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476726 | L00 - Piano Terra Piazza ELETTRICO | 641 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476741 | L00 - Piano Terra Piazza ELETTRICO | 642 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476765 | L00 - Piano Terra Piazza ELETTRICO | 643 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476783 | L00 - Piano Terra Piazza ELETTRICO | 644 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476804 | L00 - Piano Terra Piazza ELETTRICO | 645 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476823 | L00 - Piano Terra Piazza ELETTRICO | 646 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476839 | L00 - Piano Terra Piazza ELETTRICO | 647 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9476856 | L00 - Piano Terra Piazza ELETTRICO | 648 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9477070 | L00 - Piano Terra Piazza ELETTRICO | 649 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477084 | L00 - Piano Terra Piazza ELETTRICO | 650 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477098 | L00 - Piano Terra Piazza ELETTRICO | 651 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477118 | L00 - Piano Terra Piazza ELETTRICO | 652 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477142 | L00 - Piano Terra Piazza ELETTRICO | 653 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477160 | L00 - Piano Terra Piazza ELETTRICO | 654 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477180 | L00 - Piano Terra Piazza ELETTRICO | 655 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477199 | L00 - Piano Terra Piazza ELETTRICO | 656 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477221 | L00 - Piano Terra Piazza ELETTRICO | 657 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477236 | L00 - Piano Terra Piazza ELETTRICO | 658 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477250 | L00 - Piano Terra Piazza ELETTRICO | 659 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477265 | L00 - Piano Terra Piazza ELETTRICO | 660 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477282 | L00 - Piano Terra Piazza ELETTRICO | 661 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477298 | L00 - Piano Terra Piazza ELETTRICO | 662 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477313 | L00 - Piano Terra Piazza ELETTRICO | 663 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477328 | L00 - Piano Terra Piazza ELETTRICO | 664 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477342 | L00 - Piano Terra Piazza ELETTRICO | 665 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477365 | L00 - Piano Terra Piazza ELETTRICO | 666 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477408 | L00 - Piano Terra Piazza ELETTRICO | 667 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477423 | L00 - Piano Terra Piazza ELETTRICO | 668 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477439 | L00 - Piano Terra Piazza ELETTRICO | 669 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477469 | L00 - Piano Terra Piazza ELETTRICO | 670 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477497 | L00 - Piano Terra Piazza ELETTRICO | 671 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477522 | L00 - Piano Terra Piazza ELETTRICO | 672 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9477583 | L00 - Piano Terra Piazza ELETTRICO | 673 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9477596 | L00 - Piano Terra Piazza ELETTRICO | 674 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9477613 | L00 - Piano Terra Piazza ELETTRICO | 675 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9477639 | L00 - Piano Terra Piazza ELETTRICO | 676 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9477640 | L00 - Piano Terra Piazza ELETTRICO | 677 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9477660 | L00 - Piano Terra Piazza ELETTRICO | 678 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477674 | L00 - Piano Terra Piazza ELETTRICO | 679 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477687 | L00 - Piano Terra Piazza ELETTRICO | 680 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477702 | L00 - Piano Terra Piazza ELETTRICO | 681 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477721 | L00 - Piano Terra Piazza ELETTRICO | 682 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477736 | L00 - Piano Terra Piazza ELETTRICO | 683 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477756 | L00 - Piano Terra Piazza ELETTRICO | 684 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477772 | L00 - Piano Terra Piazza ELETTRICO | 685 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477787 | L00 - Piano Terra Piazza ELETTRICO | 686 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477803 | L00 - Piano Terra Piazza ELETTRICO | 687 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477820 | L00 - Piano Terra Piazza ELETTRICO | 688 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9477908 | L00 - Piano Terra Piazza ELETTRICO | 689 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9477921 | L00 - Piano Terra Piazza ELETTRICO | 690 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9477934 | L00 - Piano Terra Piazza ELETTRICO | 691 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9477948 | L00 - Piano Terra Piazza ELETTRICO | 692 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9477966 | L00 - Piano Terra Piazza ELETTRICO | 693 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9477979 | L00 - Piano Terra Piazza ELETTRICO | 694 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9477993 | L00 - Piano Terra Piazza ELETTRICO | 695 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9478005 | L00 - Piano Terra Piazza ELETTRICO | 696 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9478050 | L00 - Piano Terra Piazza ELETTRICO | 697 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9478069 | L00 - Piano Terra Piazza ELETTRICO | 698 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9478093 | L00 - Piano Terra Piazza ELETTRICO | 699 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9478105 | L00 - Piano Terra Piazza ELETTRICO | 700 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9478116 | L00 - Piano Terra Piazza ELETTRICO | 701 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 3
9478344 | L00 - Piano Terra Piazza ELETTRICO | 704 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478362 | L00 - Piano Terra Piazza ELETTRICO | 705 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478382 | L00 - Piano Terra Piazza ELETTRICO | 706 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478403 | L00 - Piano Terra Piazza ELETTRICO | 707 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478415 | L00 - Piano Terra Piazza ELETTRICO | 708 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478428 | L00 - Piano Terra Piazza ELETTRICO | 709 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478438 | L00 - Piano Terra Piazza ELETTRICO | 710 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478451 | L00 - Piano Terra Piazza ELETTRICO | 711 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478610 | L00 - Piano Terra Piazza ELETTRICO | 712 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478623 | L00 - Piano Terra Piazza ELETTRICO | 713 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9478784 | L00 - Piano Terra Piazza ELETTRICO | 714 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9478882 | L00 - Piano Terra Piazza ELETTRICO | 715 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9478926 | L00 - Piano Terra Piazza ELETTRICO | 716 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3.5
9478928 | L00 - Piano Terra Piazza ELETTRICO | 717 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3.5
9478949 | L00 - Piano Terra Piazza ELETTRICO | 718 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
9479020 | L00 - Piano Terra Piazza ELETTRICO | 719 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479075 | L00 - Piano Terra Piazza ELETTRICO | 720 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479084 | L00 - Piano Terra Piazza ELETTRICO | 721 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479095 | L00 - Piano Terra Piazza ELETTRICO | 722 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479106 | L00 - Piano Terra Piazza ELETTRICO | 723 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479175 | L00 - Piano Terra Piazza ELETTRICO | 724 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.9
9479295 | L00 - Piano Terra Piazza ELETTRICO | 725 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.78
9479339 | L00 - Piano Terra Piazza ELETTRICO | 726 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479368 | L00 - Piano Terra Piazza ELETTRICO | 727 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479379 | L00 - Piano Terra Piazza ELETTRICO | 728 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9479792 | L00 - Piano Terra Piazza ELETTRICO | 731 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 4.78
9480060 | L02 - Piano Secondo ELETTRICO | 732 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9480084 | L02 - Piano Secondo ELETTRICO | 733 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480129 | L02 - Piano Secondo ELETTRICO | 734 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9480140 | L02 - Piano Secondo ELETTRICO | 735 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9480148 | L02 - Piano Secondo ELETTRICO | 736 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480158 | L02 - Piano Secondo ELETTRICO | 737 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480168 | L02 - Piano Secondo ELETTRICO | 738 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480180 | L02 - Piano Secondo ELETTRICO | 739 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480188 | L02 - Piano Secondo ELETTRICO | 740 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480196 | L02 - Piano Secondo ELETTRICO | 741 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480245 | L02 - Piano Secondo ELETTRICO | 742 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480255 | L02 - Piano Secondo ELETTRICO | 743 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480263 | L02 - Piano Secondo ELETTRICO | 744 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480271 | L02 - Piano Secondo ELETTRICO | 745 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480281 | L02 - Piano Secondo ELETTRICO | 746 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480291 | L02 - Piano Secondo ELETTRICO | 747 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480337 | L02 - Piano Secondo ELETTRICO | 748 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480353 | L02 - Piano Secondo ELETTRICO | 749 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480380 | L02 - Piano Secondo ELETTRICO | 750 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480388 | L02 - Piano Secondo ELETTRICO | 751 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480396 | L02 - Piano Secondo ELETTRICO | 752 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480404 | L02 - Piano Secondo ELETTRICO | 753 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480412 | L02 - Piano Secondo ELETTRICO | 754 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480422 | L02 - Piano Secondo ELETTRICO | 755 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480432 | L02 - Piano Secondo ELETTRICO | 756 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480442 | L02 - Piano Secondo ELETTRICO | 757 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480452 | L02 - Piano Secondo ELETTRICO | 758 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480464 | L02 - Piano Secondo ELETTRICO | 759 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480472 | L02 - Piano Secondo ELETTRICO | 760 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480480 | L02 - Piano Secondo ELETTRICO | 761 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480488 | L02 - Piano Secondo ELETTRICO | 762 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480496 | L02 - Piano Secondo ELETTRICO | 763 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480506 | L02 - Piano Secondo ELETTRICO | 764 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480514 | L02 - Piano Secondo ELETTRICO | 765 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480522 | L02 - Piano Secondo ELETTRICO | 766 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480530 | L02 - Piano Secondo ELETTRICO | 767 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480540 | L02 - Piano Secondo ELETTRICO | 768 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480548 | L02 - Piano Secondo ELETTRICO | 769 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480560 | L02 - Piano Secondo ELETTRICO | 770 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480570 | L02 - Piano Secondo ELETTRICO | 771 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480582 | L02 - Piano Secondo ELETTRICO | 772 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480594 | L02 - Piano Secondo ELETTRICO | 773 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480606 | L02 - Piano Secondo ELETTRICO | 774 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480616 | L02 - Piano Secondo ELETTRICO | 775 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480626 | L02 - Piano Secondo ELETTRICO | 776 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480634 | L02 - Piano Secondo ELETTRICO | 777 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480644 | L02 - Piano Secondo ELETTRICO | 778 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480654 | L02 - Piano Secondo ELETTRICO | 779 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480662 | L02 - Piano Secondo ELETTRICO | 780 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9480709 | L02 - Piano Secondo ELETTRICO | 781 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480718 | L02 - Piano Secondo ELETTRICO | 782 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480727 | L02 - Piano Secondo ELETTRICO | 783 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480738 | L02 - Piano Secondo ELETTRICO | 784 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480769 | L02 - Piano Secondo ELETTRICO | 785 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480778 | L02 - Piano Secondo ELETTRICO | 786 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480787 | L02 - Piano Secondo ELETTRICO | 787 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480800 | L02 - Piano Secondo ELETTRICO | 788 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9480811 | L02 - Piano Secondo ELETTRICO | 789 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9481020 | L02 - Piano Secondo ELETTRICO | 790 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9481032 | L02 - Piano Secondo ELETTRICO | 791 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9481119 | L02 - Piano Secondo ELETTRICO | 792 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.784
9481155 | L02 - Piano Secondo ELETTRICO | 793 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9481411 | B01 - Piano Interrato ELETTRICO | 794 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9481426 | B01 - Piano Interrato ELETTRICO | 795 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9481470 | B01 - Piano Interrato ELETTRICO | 796 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9481507 | B01 - Piano Interrato ELETTRICO | 797 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9481515 | B01 - Piano Interrato ELETTRICO | 798 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9481523 | B01 - Piano Interrato ELETTRICO | 799 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9481574 | B01 - Piano Interrato ELETTRICO | 800 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9481650 | B01 - Piano Interrato ELETTRICO | 801 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
9481664 | B01 - Piano Interrato ELETTRICO | 802 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
9481787 | B01 - Piano Interrato ELETTRICO | 803 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
9481799 | B01 - Piano Interrato ELETTRICO | 804 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
9481842 | B01 - Piano Interrato ELETTRICO | 805 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
9481853 | B01 - Piano Interrato ELETTRICO | 806 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.42
9481938 | B01 - Piano Interrato ELETTRICO | 808 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9482022 | B01 - Piano Interrato ELETTRICO | 809 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9482031 | B01 - Piano Interrato ELETTRICO | 810 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9482040 | B01 - Piano Interrato ELETTRICO | 811 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9482049 | B01 - Piano Interrato ELETTRICO | 812 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9482057 | L03 - Piano Terzo ELETTRICO | 813 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | -15.85
9482069 | L03 - Piano Terzo ELETTRICO | 814 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | -15.85
9482078 | L03 - Piano Terzo ELETTRICO | 815 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | -15.85
9482086 | B01 - Piano Interrato ELETTRICO | 816 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482096 | B01 - Piano Interrato ELETTRICO | 817 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482104 | B01 - Piano Interrato ELETTRICO | 818 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482114 | B01 - Piano Interrato ELETTRICO | 819 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482122 | B01 - Piano Interrato ELETTRICO | 820 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482132 | B01 - Piano Interrato ELETTRICO | 821 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482142 | B01 - Piano Interrato ELETTRICO | 822 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482150 | B01 - Piano Interrato ELETTRICO | 823 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482158 | B01 - Piano Interrato ELETTRICO | 824 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482168 | B01 - Piano Interrato ELETTRICO | 825 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482176 | B01 - Piano Interrato ELETTRICO | 826 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9482230 | B01 - Piano Interrato ELETTRICO | 827 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.6
9485561 | L03 - Piano Terzo ELETTRICO | 840 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.324

# IfcBuildingElementProxy: SMA STP50_Core 1:EEQ_I_InverterSmaStp50_Core1 (5)
Type - Material: SMA White Rexel
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: SMA STP50_Core 1
Type - Dati identità - Article number Rexel: 2850200017; BIM Content creator: Rexel Netherlands; Commenti sul tipo: INV; Distributor: Rexel; Modello: STP50-40; Nome del tipo: EEQ_I_InverterSmaStp50_Core1; Numero OmniClass: 23.80.30.11.17; Produttore: SMA; Technical Support Rexel Email: ts@rexel.nl; Technical Support Rexel Phone: +3188-500 71 80; Titolo OmniClass: Distribution Boards and Control Panels; URL: https://mep.trimble.com
Type - Dimensioni - Inverter Depth: 0.569 m; Inverter height: 0.733 m; Inverter width: 0.621 m
Type - Elettrico - Max. apparent power AC: 50000 W; Max. input voltage: 1000 V; Max. output current: 72.5 A; Min. input voltage: 150 V; Voltaggio: 400
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_I_InverterSmaStp50_Core1
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_I_InverterSmaStp50_Core1
Type - Pset_ManufacturerTypeInformation - Manufacturer: SMA
Material: SMA White Rexel, SMA BLACK PLASTIC, Rexel, Plastic, Blue LED SMA, Rexel, Plastic, Light gray SMA, Rexel, Plastic, Green LED SMA, Rexel_Aluminum, Anodized White SMA
Altro - Famiglia: SMA STP50_Core 1: EEQ_I_InverterSmaStp50_Core1; Famiglia e tipo: SMA STP50_Core 1: EEQ_I_InverterSmaStp50_Core1; ID tipo: SMA STP50_Core 1: EEQ_I_InverterSmaStp50_Core1; Tipo: SMA STP50_Core 1: EEQ_I_InverterSmaStp50_Core1
Dimensioni - Area: 7.78492 m2; Volume: 0.182152 m3
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase A carico apparente capicorda passanti: 0 W; Fase A carico apparente circuito derivato: 0 W; Fase B carico apparente: 0 W; Fase B carico apparente capicorda passanti: 0 W; Fase B carico apparente circuito derivato: 0 W; Fase C carico apparente: 0 W; Fase C carico apparente capicorda passanti: 0 W; Fase C carico apparente circuito derivato: 0 W; Fattore di richiesta totale: 100; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Elettrico - Circuiti - Capicorda alimentazione secondaria: yes; Capicorda passanti: yes; Opzione numerazione circuiti: Default; Corrente nominale interruttore automatico principale: 1 A
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Sposta con l'oggetto più vicino: no; Offset da host: 0 m; Quota altimetrica da livello: 0 m
Name (SMA STP50_Core 1:...) | In | Contrassegno | Nome quadro | Livello | Host
Inverter 3:10403015 | L03 - Piano Terzo ELETTRICO | 652 | Inverter 3 | Livello: L03 - Piano Terzo ELETTRICO | Livello : L03 - Piano Terzo ELETTRICO
Inverter 2:10403026 | L03 - Piano Terzo ELETTRICO | 653 | Inverter 2 | Livello: L03 - Piano Terzo ELETTRICO | Livello : L03 - Piano Terzo ELETTRICO
Inverter 1:10403037 | L03 - Piano Terzo ELETTRICO | 654 | Inverter 1 | Livello: L03 - Piano Terzo ELETTRICO | Livello : L03 - Piano Terzo ELETTRICO
Inverter 4:10403051 | L02 - Piano Secondo ELETTRICO | 655 | Inverter 4 | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO
Inverter 5:10403062 | L02 - Piano Secondo ELETTRICO | 656 | Inverter 5 | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO

# IfcBuildingElementProxy: Sirena Antintrusione:Sirena Antintrusione (11)
Type - Material: Sostegno tromba audio
Type - Altro - Categoria: Dispositivi di sicurezza; Nome famiglia: Sirena Antintrusione
Type - Dati identità - Commenti sul tipo: SAI; Nome del tipo: Sirena Antintrusione
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Sirena Antintrusione
Type - Pset_EnvironmentalImpactIndicators - Reference: Sirena Antintrusione
Material: Sostegno tromba audio, ABS tromba audio
Altro - Famiglia: Sirena Antintrusione: Sirena Antintrusione; Famiglia e tipo: Sirena Antintrusione: Sirena Antintrusione; ID tipo: Sirena Antintrusione: Sirena Antintrusione; Tipo: Sirena Antintrusione: Sirena Antintrusione
Dimensioni - Inclinazione: 60 deg; Volume: 0.000861788 m3
Fasi - Fase di creazione: Nuova costruzione
Name (Sirena Antintrusione:Sirena Antintrusione:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
10344498 | L00 - Piano Terra Piazza ELETTRICO | 533 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.8
10344500 | L00 - Piano Terra Piazza ELETTRICO | 534 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.8
10344505 | B01 - Piano Interrato ELETTRICO | 537 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
10344506 | B01 - Piano Interrato ELETTRICO | 538 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.4
10344507 | L00 - Piano Terra Piazza ELETTRICO | 539 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.9
10344509 | L00 - Piano Terra Piazza ELETTRICO | 540 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.9
10344516 | L00 - Piano Terra Piazza ELETTRICO | 541 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.9
10344517 | L02 - Piano Secondo ELETTRICO | 542 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.9
10344518 | L02 - Piano Secondo ELETTRICO | 543 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.9
10477482 | L02 - Piano Secondo ELETTRICO | 546 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.154817
10477571 | L02 - Piano Secondo ELETTRICO | 547 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.31363

# IfcBuildingElementProxy: Tastiera allarme antintrusione:DSE_I_TastieraAllarmeAntintrusione (4)
Type - Material: Tasti tastiera allarme
Type - Altro - Categoria: Dispositivi di sicurezza; Nome famiglia: Tastiera allarme antintrusione
Type - Dati identità - Commenti sul tipo: SAI; Nome del tipo: DSE_I_TastieraAllarmeAntintrusione
Type - Vincoli - Prospetto di default: 1.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DSE_I_TastieraAllarmeAntintrusione
Type - Pset_EnvironmentalImpactIndicators - Reference: DSE_I_TastieraAllarmeAntintrusione
Material: Tasti tastiera allarme, Spie tastiera allarme verde, Spie tastiera allarme gialla, Spie tastiera allarme rossa, Display tastiera allarme, Scatola tastiera allarme
Altro - Famiglia: Tastiera allarme antintrusione: DSE_I_TastieraAllarmeAntintrusione; Famiglia e tipo: Tastiera allarme antintrusione: DSE_I_TastieraAllarmeAntintrusione; ID tipo: Tastiera allarme antintrusione: DSE_I_TastieraAllarmeAntintrusione; Tipo: Tastiera allarme antintrusione: DSE_I_TastieraAllarmeAntintrusione
Dimensioni - Volume: 0.00016516 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Quota altimetrica da livello: 1.3 m
Name (Tastiera allarme antintrusione:DSE_I_TastieraAllarmeAntintrusione:...) | In | Contrassegno | Livello = Livello abaco | Host
10344493 | B01 - Piano Interrato ELETTRICO | 528 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10344494 | B01 - Piano Interrato ELETTRICO | 530 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
10344495 | L00 - Piano Terra Piazza ELETTRICO | 531 | Livello: L00 - Piano Terra Piazza ELETTRICO | Dati : DDA_I_DatiDoppia
10344497 | L00 - Piano Terra Piazza ELETTRICO | 532 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Torretta tipo 2 bilaterale:EFX_I_TorrettaT0-1 (52)
Type - Material: Socket, Floor Socket-Stainless Steel
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Torretta tipo 2 bilaterale
Type - Dati identità - Commenti sul tipo: 1; Contrassegno tipo: 1; Nome del tipo: EFX_I_TorrettaT0-1; Numero OmniClass: 23.80.30.00; Titolo OmniClass: Distribution Devices
Type - Materiali e finiture - Floor Socket Material: Floor Socket-Stainless Steel; Socket Material: Socket
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - Reference: EFX_I_TorrettaT0-1; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_TorrettaT0-1
Altro - Famiglia: Torretta tipo 2 bilaterale: EFX_I_TorrettaT0-1; Famiglia e tipo: Torretta tipo 2 bilaterale: EFX_I_TorrettaT0-1; ID tipo: Torretta tipo 2 bilaterale: EFX_I_TorrettaT0-1; Tipo: Torretta tipo 2 bilaterale: EFX_I_TorrettaT0-1
Dimensioni - Volume: 0.00189183 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Name (Torretta tipo 2 bilaterale:EFX_I_TorrettaT0-1:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
8708284 | B01 - Piano Interrato ELETTRICO | 3630 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.7 | Dati identità - Commenti: Aula magna
8714057 | B01 - Piano Interrato ELETTRICO | 3634 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.7 | Dati identità - Commenti: Aula magna
8714069 | B01 - Piano Interrato ELETTRICO | 3635 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.7 | Dati identità - Commenti: Aula magna
8714079 | B01 - Piano Interrato ELETTRICO | 3636 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.7 | Dati identità - Commenti: Aula magna
8783218 | L00 - Piano Terra Piazza ELETTRICO | 3717 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0
8783322 | L00 - Piano Terra Piazza ELETTRICO | 3718 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0
8783409 | L00 - Piano Terra Piazza ELETTRICO | 3720 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0
8783509 | L00 - Piano Terra Piazza ELETTRICO | 3721 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0
8829853 | L00 - Piano Terra Piazza ELETTRICO | 3728 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0
