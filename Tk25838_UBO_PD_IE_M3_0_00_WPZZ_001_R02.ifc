Properties of the parts of a building model (IFC4), part 7 of 23

# IfcBuildingElementProxy: Pannello Fotovoltaico:EEQ_E_PannelloFotovoltaico (564)
Name (Pannello Fotovoltaico:EEQ_E_PannelloFotovoltaico:...) | Host | Quota altimetrica da livello (m)
9321547 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321548 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321549 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321550 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321551 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321552 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321553 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321554 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321555 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321556 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321557 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321558 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321559 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321560 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321561 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321562 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321563 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321564 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321565 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321566 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321567 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321571 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321572 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321573 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321582 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321583 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321584 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321585 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321586 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321587 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321588 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321589 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321590 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321591 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321592 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321593 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321594 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321595 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321596 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321597 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321598 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321599 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321600 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321601 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321602 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321603 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321604 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321605 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321606 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321607 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321608 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321609 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321610 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321611 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321624 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321625 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321626 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321627 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321628 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321629 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321630 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321631 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321632 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321633 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321634 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321635 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321636 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321637 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321638 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321639 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321640 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321641 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321642 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321643 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321644 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321645 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321646 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321647 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321648 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321649 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321650 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321651 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321652 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321653 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321665 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321666 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321667 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321668 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321669 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321670 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321671 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321672 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321673 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321674 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321675 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321676 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321677 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321678 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321679 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321680 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321681 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321682 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321683 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321684 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321685 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321686 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321687 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321688 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321689 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321690 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321691 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321704 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321705 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321706 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321707 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321708 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321709 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321710 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321711 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321712 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321713 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321714 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321715 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321716 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321717 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321718 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321719 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321720 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321721 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321722 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321723 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321724 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321725 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321726 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321727 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321728 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321729 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321730 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321771 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321772 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321773 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321774 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321775 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321776 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321777 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321778 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321779 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321780 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321781 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321782 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321783 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321785 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321787 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321789 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321791 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321793 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321795 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321797 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321799 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321801 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321803 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321807 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321808 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321809 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9321810 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9327982 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9327994 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328024 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328080 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328081 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328082 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328093 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328094 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328095 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328106 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328107 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328108 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328172 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328180 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328188 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328196 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328210 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328220 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328245 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328246 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328247 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328248 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328249 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328250 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328260 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328261 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328262 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328263 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328264 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328265 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328275 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328276 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328277 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328278 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328279 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328280 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328540 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328541 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328542 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328543 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328544 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328545 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328546 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328547 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328549 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328550 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328552 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328553 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328604 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328605 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328606 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328607 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328608 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328609 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328610 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328611 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328612 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328613 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328629 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328630 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328631 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328632 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328633 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328634 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328635 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328636 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328637 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328638 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328639 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328642 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328643 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328644 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328645 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328646 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328647 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328657 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328658 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328659 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328663 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328664 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328665 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328666 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328667 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328668 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328669 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328670 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328671 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328672 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328673 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328676 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328677 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328678 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328679 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328680 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328681 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
9328938 | <non associato> | -4.02601
9329147 | <non associato> | -4.00032
9329310 | <non associato> | -3.97462
9329322 | <non associato> | -3.94892
9329332 | <non associato> | -3.92323
9329342 | <non associato> | -3.89753
9329352 | <non associato> | -3.87183
9329360 | <non associato> | -3.84613
9329370 | <non associato> | -3.82044
9329406 | <non associato> | -4.0261
9329408 | <non associato> | -4.0004
9329410 | <non associato> | -3.9747
9329411 | <non associato> | -3.94901
9329412 | <non associato> | -3.92331
9329413 | <non associato> | -3.89761
9329414 | <non associato> | -3.87192
9329415 | <non associato> | -3.84622
9329416 | <non associato> | -3.82052
9329483 | <non associato> | -4.02619
9329484 | <non associato> | -4.00049
9329486 | <non associato> | -3.97479
9329487 | <non associato> | -3.94909
9329488 | <non associato> | -3.9234
9329489 | <non associato> | -3.8977
9329490 | <non associato> | -3.872
9329491 | <non associato> | -3.84631
9329492 | <non associato> | -3.82061
9329500 | <non associato> | -4.02627
9329501 | <non associato> | -4.00058
9329503 | <non associato> | -3.97488
9329504 | <non associato> | -3.94918
9329505 | <non associato> | -3.92348
9329506 | <non associato> | -3.89779
9329507 | <non associato> | -3.87209
9329508 | <non associato> | -3.84639
9329509 | <non associato> | -3.82069
9329517 | <non associato> | -4.02636
9329518 | <non associato> | -4.00066
9329520 | <non associato> | -3.97496
9329521 | <non associato> | -3.94927
9329522 | <non associato> | -3.92357
9329523 | <non associato> | -3.89787
9329524 | <non associato> | -3.87218
9329525 | <non associato> | -3.84648
9329526 | <non associato> | -3.82078
9329534 | <non associato> | -4.02645
9329535 | <non associato> | -4.00075
9329537 | <non associato> | -3.97505
9329538 | <non associato> | -3.94935
9329539 | <non associato> | -3.92366
9329540 | <non associato> | -3.89796
9329541 | <non associato> | -3.87226
9329542 | <non associato> | -3.84656
9329543 | <non associato> | -3.82087
9329551 | <non associato> | -4.02653
9329552 | <non associato> | -4.00083
9329554 | <non associato> | -3.97514
9329555 | <non associato> | -3.94944
9329556 | <non associato> | -3.92374
9329557 | <non associato> | -3.89805
9329558 | <non associato> | -3.87235
9329559 | <non associato> | -3.84665
9329560 | <non associato> | -3.82095
9329568 | <non associato> | -4.02662
9329569 | <non associato> | -4.00092
9329571 | <non associato> | -3.97522
9329572 | <non associato> | -3.94953
9329573 | <non associato> | -3.92383
9329574 | <non associato> | -3.89813
9329575 | <non associato> | -3.87243
9329576 | <non associato> | -3.84674
9329577 | <non associato> | -3.82104
9329591 | <non associato> | -4.0267
9329592 | <non associato> | -4.00101
9329594 | <non associato> | -3.97531
9329595 | <non associato> | -3.94961
9329596 | <non associato> | -3.92392
9329597 | <non associato> | -3.89822
9329598 | <non associato> | -3.87252
9329599 | <non associato> | -3.84682
9329600 | <non associato> | -3.82113
9329608 | <non associato> | -4.02679
9329609 | <non associato> | -4.00109
9329611 | <non associato> | -3.97539
9329612 | <non associato> | -3.9497
9329613 | <non associato> | -3.924
9329614 | <non associato> | -3.8983
9329615 | <non associato> | -3.87261
9329616 | <non associato> | -3.84691
9329617 | <non associato> | -3.82121
9329625 | <non associato> | -4.02688
9329626 | <non associato> | -4.00118
9329628 | <non associato> | -3.97548
9329629 | <non associato> | -3.94979
9329630 | <non associato> | -3.92409
9329631 | <non associato> | -3.89839
9329632 | <non associato> | -3.87269
9329633 | <non associato> | -3.847
9329634 | <non associato> | -3.8213
9329676 | <non associato> | -4.02696
9329677 | <non associato> | -4.00126
9329679 | <non associato> | -3.97557
9329680 | <non associato> | -3.94987
9329681 | <non associato> | -3.92417
9329682 | <non associato> | -3.89848
9329683 | <non associato> | -3.87278
9329684 | <non associato> | -3.84708
9329685 | <non associato> | -3.82138
9329686 | <non associato> | -4.02705
9329687 | <non associato> | -4.00135
9329689 | <non associato> | -3.97565
9329690 | <non associato> | -3.94996
9329691 | <non associato> | -3.92426
9329692 | <non associato> | -3.89856
9329693 | <non associato> | -3.87286
9329694 | <non associato> | -3.84717
9329695 | <non associato> | -3.82147
9329706 | <non associato> | -4.02722
9329707 | <non associato> | -4.00152
9329709 | <non associato> | -3.97582
9329710 | <non associato> | -3.95013
9329711 | <non associato> | -3.92443
9329712 | <non associato> | -3.89873
9329713 | <non associato> | -3.87304
9329714 | <non associato> | -3.84734
9329715 | <non associato> | -3.82164
9329716 | <non associato> | -4.02731
9329717 | <non associato> | -4.00161
9329719 | <non associato> | -3.97591
9329720 | <non associato> | -3.95021
9329721 | <non associato> | -3.92452
9329722 | <non associato> | -3.89882
9329723 | <non associato> | -3.87312
9329724 | <non associato> | -3.84743
9329725 | <non associato> | -3.82173
9329726 | <non associato> | -4.02739
9329727 | <non associato> | -4.0017
9329729 | <non associato> | -3.976
9329730 | <non associato> | -3.9503
9329731 | <non associato> | -3.9246
9329732 | <non associato> | -3.89891
9329733 | <non associato> | -3.87321
9329734 | <non associato> | -3.84751
9329735 | <non associato> | -3.82181
9329736 | <non associato> | -4.02748
9329737 | <non associato> | -4.00178
9329739 | <non associato> | -3.97608
9329740 | <non associato> | -3.95039
9329741 | <non associato> | -3.92469
9329742 | <non associato> | -3.89899
9329743 | <non associato> | -3.8733
9329744 | <non associato> | -3.8476
9329745 | <non associato> | -3.8219
9329746 | <non associato> | -4.02757
9329747 | <non associato> | -4.00187
9329749 | <non associato> | -3.97617
9329750 | <non associato> | -3.95047
9329751 | <non associato> | -3.92478
9329752 | <non associato> | -3.89908
9329753 | <non associato> | -3.87338
9329754 | <non associato> | -3.84768
9329755 | <non associato> | -3.82199
9329756 | <non associato> | -4.02765
9329757 | <non associato> | -4.00195
9329759 | <non associato> | -3.97626
9329760 | <non associato> | -3.95056
9329761 | <non associato> | -3.92486
9329762 | <non associato> | -3.89917
9329763 | <non associato> | -3.87347
9329764 | <non associato> | -3.84777
9329765 | <non associato> | -3.82207
9329766 | <non associato> | -4.02774
9329767 | <non associato> | -4.00204
9329769 | <non associato> | -3.97634
9329770 | <non associato> | -3.95065
9329771 | <non associato> | -3.92495
9329772 | <non associato> | -3.89925
9329773 | <non associato> | -3.87355
9329774 | <non associato> | -3.84786
9329775 | <non associato> | -3.82216
9329803 | <non associato> | -4.02782
9329804 | <non associato> | -4.00213
9329806 | <non associato> | -3.97643
9329807 | <non associato> | -3.95073
9329808 | <non associato> | -3.92503
9329809 | <non associato> | -3.89934
9329810 | <non associato> | -3.87364
9329811 | <non associato> | -3.84794
9329812 | <non associato> | -3.82225
9329813 | <non associato> | -4.02791
9329814 | <non associato> | -4.00221
9329816 | <non associato> | -3.97651
9329817 | <non associato> | -3.95082
9329818 | <non associato> | -3.92512
9329819 | <non associato> | -3.89942
9329820 | <non associato> | -3.87373
9329821 | <non associato> | -3.84803
9329822 | <non associato> | -3.82233
9329823 | <non associato> | -4.028
9329824 | <non associato> | -4.0023
9329826 | <non associato> | -3.9766
9329827 | <non associato> | -3.9509
9329828 | <non associato> | -3.92521
9329829 | <non associato> | -3.89951
9329830 | <non associato> | -3.87381
9329831 | <non associato> | -3.84812
9329832 | <non associato> | -3.82242
9329833 | <non associato> | -4.02808
9329834 | <non associato> | -4.00239
9329836 | <non associato> | -3.97669
9329837 | <non associato> | -3.95099
9329838 | <non associato> | -3.92529
9329839 | <non associato> | -3.8996
9329840 | <non associato> | -3.8739
9329841 | <non associato> | -3.8482
9329842 | <non associato> | -3.8225
9329843 | <non associato> | -4.02817
9329844 | <non associato> | -4.00247
9329846 | <non associato> | -3.97677
9329847 | <non associato> | -3.95108
9329848 | <non associato> | -3.92538
9329849 | <non associato> | -3.89968
9329850 | <non associato> | -3.87399
9329851 | <non associato> | -3.84829
9329852 | <non associato> | -3.82259
9329884 | <non associato> | -4.02826
9329885 | <non associato> | -4.00256
9329887 | <non associato> | -3.97686
9329888 | <non associato> | -3.95116
9329889 | <non associato> | -3.92547
9329890 | <non associato> | -3.89977
9329891 | <non associato> | -3.87407
9329892 | <non associato> | -3.84837
10396573 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
10396574 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
10396608 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
10396609 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.326
10396680 | <non associato> | -3.82268

# IfcBuildingElementProxy: Prese CEE 2P+T:EFX_I_Cee2P+T16AEsterna (6)
Type - Material: Plastica
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Prese CEE 2P+T; Tipologia presa: CEE 2P+T esterna
Type - Dati identità - Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_Cee2P+T16AEsterna; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Ingegneria elettrica - Corrente Nominale: 16 A
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Cee2P+T16AEsterna
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Cee2P+T16AEsterna
Material: Plastica, Nuovo materiale di default, Metallo
Altro - Famiglia: Prese CEE 2P+T: EFX_I_Cee2P+T16AEsterna; Famiglia e tipo: Prese CEE 2P+T: EFX_I_Cee2P+T16AEsterna; ID tipo: Prese CEE 2P+T: EFX_I_Cee2P+T16AEsterna; Tipo: Prese CEE 2P+T: EFX_I_Cee2P+T16AEsterna
Dimensioni - Distanza_simbolo: 0.5 m; Volume: 0.00192889 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Testo - Corrente A: 16A
Vincoli - Offset da host: 0 m
Name (Prese CEE 2P+T:EFX_I_Cee2P+T16AEsterna:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9885928 | B01 - Piano Interrato ELETTRICO | 4536 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.1 | Dati identità - Commenti: Aula magna
9892923 | B01 - Piano Interrato ELETTRICO | 4546 | Livello: B01 - Piano Interrato ELETTRICO | Prese CEE 3P+T : EFX_I_Cee3P+T16AEsterna | 1.1 | Dati identità - Commenti: Aula magna
10315187 | L04 - Piano Copertura ELETTRICO | 4702 | Livello: L04 - Piano Copertura ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.974
10315248 | L04 - Piano Copertura ELETTRICO | 4704 | Livello: L04 - Piano Copertura ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.974
10319325 | B01 - Piano Interrato ELETTRICO | 4705 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.1
10319511 | B01 - Piano Interrato ELETTRICO | 4708 | Livello: B01 - Piano Interrato ELETTRICO | Prese CEE 3P+T : EFX_I_Cee3P+T16AEsterna | 1.1

# IfcBuildingElementProxy: Prese CEE 3P+T:EFX_I_Cee3P+T16AEsterna (6)
Type - Material: Plastica
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Prese CEE 3P+T; Tipologia presa: CEE 3P+T esterna
Type - Dati identità - Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_Cee3P+T16AEsterna; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Ingegneria elettrica - Corrente Nominale: 16 A
Type - Testo - Corrente A: 16A
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Cee3P+T16AEsterna
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Cee3P+T16AEsterna
Material: Plastica, Nuovo materiale di default rosso, Metallo
Altro - Famiglia: Prese CEE 3P+T: EFX_I_Cee3P+T16AEsterna; Famiglia e tipo: Prese CEE 3P+T: EFX_I_Cee3P+T16AEsterna; ID tipo: Prese CEE 3P+T: EFX_I_Cee3P+T16AEsterna; Tipo: Prese CEE 3P+T: EFX_I_Cee3P+T16AEsterna
Dimensioni - Area: 0.0725419 m2; Distanza_simbolo: 0.5 m; Volume: 0.00192776 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 0 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (Prese CEE 3P+T:EFX_I_Cee3P+T16AEsterna:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9885966 | B01 - Piano Interrato ELETTRICO | 4537 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.1 | Dati identità - Commenti: Aula magna
9892896 | B01 - Piano Interrato ELETTRICO | 4545 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.1 | Dati identità - Commenti: Aula magna
10315039 | L04 - Piano Copertura ELETTRICO | 4701 | Livello: L04 - Piano Copertura ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.974
10315246 | L04 - Piano Copertura ELETTRICO | 4703 | Livello: L04 - Piano Copertura ELETTRICO | Prese CEE 2P+T : EFX_I_Cee2P+T16AEsterna | 0.974
10319376 | B01 - Piano Interrato ELETTRICO | 4706 | Livello: B01 - Piano Interrato ELETTRICO | Prese CEE 2P+T : EFX_I_Cee2P+T16AEsterna | 1.1
10319451 | B01 - Piano Interrato ELETTRICO | 4707 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1

# IfcBuildingElementProxy: Prese:EFX_I_Unel+Bipasso (113)
Type - Material: Frutto
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: 05 - Unel + Bipasso; Nome famiglia: Prese
Type - Dati identità - Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_Unel+Bipasso; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 120 V
Type - Grafica - Simbolo: 05
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Unel+Bipasso
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Unel+Bipasso
Material: Frutto, Placca
Altro - Famiglia: Prese: EFX_I_Unel+Bipasso; Famiglia e tipo: Prese: EFX_I_Unel+Bipasso; ID tipo: Prese: EFX_I_Unel+Bipasso; Tipo: Prese: EFX_I_Unel+Bipasso
Dimensioni - Area: 0.0233356 m2; Volume: 0.00012899 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-200 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Quota altimetrica da livello: 0.35 m
Name (Prese:EFX_I_Unel+Bipasso:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Host
8715628 | L00 - Piano Terra Piazza ELETTRICO | 3647 | 0.258658 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8715933 | L00 - Piano Terra Piazza ELETTRICO | 3649 | 0.239337 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8716199 | L00 - Piano Terra Piazza ELETTRICO | 3650 | 0.0269978 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8716412 | L00 - Piano Terra Piazza ELETTRICO | 3653 | 0.7 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8717394 | L00 - Piano Terra Piazza ELETTRICO | 3655 | 0.305195 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8717522 | L00 - Piano Terra Piazza ELETTRICO | 3657 | 0.342152 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8717875 | L00 - Piano Terra Piazza ELETTRICO | 3659 | 0.794639 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8718020 | L00 - Piano Terra Piazza ELETTRICO | 3661 | 0.469643 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8718949 | L00 - Piano Terra Piazza ELETTRICO | 3663 | 0.0717952 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8719094 | L00 - Piano Terra Piazza ELETTRICO | 3665 | 0.5631 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8719358 | L00 - Piano Terra Piazza ELETTRICO | 3667 | 0.5631 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8719455 | L00 - Piano Terra Piazza ELETTRICO | 3669 | 0.0587418 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8720916 | L00 - Piano Terra Piazza ELETTRICO | 3673 | 0.269561 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8721060 | L00 - Piano Terra Piazza ELETTRICO | 3675 | 0.38903 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8721140 | L00 - Piano Terra Piazza ELETTRICO | 3677 | 0.295527 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8723233 | L00 - Piano Terra Piazza ELETTRICO | 3682 | 0.7 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8723362 | L00 - Piano Terra Piazza ELETTRICO | 3684 | 0.7 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8723456 | L00 - Piano Terra Piazza ELETTRICO | 3686 | 0.7 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8828623 | L00 - Piano Terra Piazza ELETTRICO | 3723 | 0.7 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8828780 | L00 - Piano Terra Piazza ELETTRICO | 3725 | 0.7 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8828946 | L00 - Piano Terra Piazza ELETTRICO | 3727 | 0.7 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt
8967097 | L00 - Piano Terra Piazza ELETTRICO | 3818 | 0.720293 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8967419 | L00 - Piano Terra Piazza ELETTRICO | 3819 | 0.737824 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8968535 | L00 - Piano Terra Piazza ELETTRICO | 3821 | 0.586613 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8968683 | L00 - Piano Terra Piazza ELETTRICO | 3823 | 0.414209 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8969032 | L00 - Piano Terra Piazza ELETTRICO | 3825 | 0.53423 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8969247 | L00 - Piano Terra Piazza ELETTRICO | 3828 | 0.308827 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8970676 | L00 - Piano Terra Piazza ELETTRICO | 3833 | 0.711804 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8970804 | L00 - Piano Terra Piazza ELETTRICO | 3835 | 0.737148 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8971017 | L00 - Piano Terra Piazza ELETTRICO | 3837 | 0.729925 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8971243 | L00 - Piano Terra Piazza ELETTRICO | 3839 | 0.710335 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8971876 | L00 - Piano Terra Piazza ELETTRICO | 3841 | 0.717852 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8972156 | L00 - Piano Terra Piazza ELETTRICO | 3843 | 0.711904 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8972487 | L00 - Piano Terra Piazza ELETTRICO | 3845 | 0.675913 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8972938 | L00 - Piano Terra Piazza ELETTRICO | 3848 | 0.772475 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8973113 | L00 - Piano Terra Piazza ELETTRICO | 3849 | 0.721127 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8973543 | L00 - Piano Terra Piazza ELETTRICO | 3852 | 0.74479 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8973779 | L00 - Piano Terra Piazza ELETTRICO | 3853 | 0.711734 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8973963 | L00 - Piano Terra Piazza ELETTRICO | 3855 | 0.700129 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8974803 | L00 - Piano Terra Piazza ELETTRICO | 3857 | 0.721465 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8975043 | L00 - Piano Terra Piazza ELETTRICO | 3859 | 0.72788 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8975538 | L00 - Piano Terra Piazza ELETTRICO | 3861 | 0.703577 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8976237 | L00 - Piano Terra Piazza ELETTRICO | 3865 | 0.736411 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8976721 | L00 - Piano Terra Piazza ELETTRICO | 3868 | 0.817879 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8976799 | L00 - Piano Terra Piazza ELETTRICO | 3869 | 0.70986 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8978896 | L00 - Piano Terra Piazza ELETTRICO | 3882 | 0.730715 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8979011 | L00 - Piano Terra Piazza ELETTRICO | 3884 | 0.723237 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8985826 | L02 - Piano Secondo ELETTRICO | 3949 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986001 | L02 - Piano Secondo ELETTRICO | 3951 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986050 | L02 - Piano Secondo ELETTRICO | 3953 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986197 | L02 - Piano Secondo ELETTRICO | 3956 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986242 | L02 - Piano Secondo ELETTRICO | 3957 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986590 | L02 - Piano Secondo ELETTRICO | 3959 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986652 | L02 - Piano Secondo ELETTRICO | 3961 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986736 | L02 - Piano Secondo ELETTRICO | 3963 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986803 | L02 - Piano Secondo ELETTRICO | 3965 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8986900 | L02 - Piano Secondo ELETTRICO | 3967 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987050 | L02 - Piano Secondo ELETTRICO | 3969 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987098 | L02 - Piano Secondo ELETTRICO | 3971 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987165 | L02 - Piano Secondo ELETTRICO | 3973 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987309 | L02 - Piano Secondo ELETTRICO | 3976 | 0.325352 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987514 | L02 - Piano Secondo ELETTRICO | 3977 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987602 | L02 - Piano Secondo ELETTRICO | 3979 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987662 | L02 - Piano Secondo ELETTRICO | 3981 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987772 | L02 - Piano Secondo ELETTRICO | 3983 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987835 | L02 - Piano Secondo ELETTRICO | 3985 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8987901 | L02 - Piano Secondo ELETTRICO | 3987 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988004 | L02 - Piano Secondo ELETTRICO | 3989 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988064 | L02 - Piano Secondo ELETTRICO | 3991 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988159 | L02 - Piano Secondo ELETTRICO | 3994 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988231 | L02 - Piano Secondo ELETTRICO | 3996 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988383 | L02 - Piano Secondo ELETTRICO | 3998 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988464 | L02 - Piano Secondo ELETTRICO | 4000 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988620 | L02 - Piano Secondo ELETTRICO | 4002 | 0.462674 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988700 | L02 - Piano Secondo ELETTRICO | 4004 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988820 | L02 - Piano Secondo ELETTRICO | 4006 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988915 | L02 - Piano Secondo ELETTRICO | 4008 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8988987 | L02 - Piano Secondo ELETTRICO | 4010 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989053 | L02 - Piano Secondo ELETTRICO | 4012 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989131 | L02 - Piano Secondo ELETTRICO | 4014 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989188 | L02 - Piano Secondo ELETTRICO | 4016 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989275 | L02 - Piano Secondo ELETTRICO | 4018 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989357 | L02 - Piano Secondo ELETTRICO | 4020 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989424 | L02 - Piano Secondo ELETTRICO | 4022 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989520 | L02 - Piano Secondo ELETTRICO | 4024 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989595 | L02 - Piano Secondo ELETTRICO | 4026 | 0.4 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989628 | L02 - Piano Secondo ELETTRICO | 4029 | 1 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989754 | L02 - Piano Secondo ELETTRICO | 4030 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989823 | L02 - Piano Secondo ELETTRICO | 4032 | 1 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989851 | L02 - Piano Secondo ELETTRICO | 4034 | 0.4 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8989946 | L02 - Piano Secondo ELETTRICO | 4036 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990021 | L02 - Piano Secondo ELETTRICO | 4038 | 1 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990043 | L02 - Piano Secondo ELETTRICO | 4040 | 0.4 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990168 | L02 - Piano Secondo ELETTRICO | 4042 | 1 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990211 | L02 - Piano Secondo ELETTRICO | 4044 | 0.4 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990295 | L02 - Piano Secondo ELETTRICO | 4046 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990508 | L02 - Piano Secondo ELETTRICO | 4048 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990546 | L02 - Piano Secondo ELETTRICO | 4050 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990735 | L02 - Piano Secondo ELETTRICO | 4052 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990853 | L02 - Piano Secondo ELETTRICO | 4054 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990875 | L02 - Piano Secondo ELETTRICO | 4056 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8990976 | L02 - Piano Secondo ELETTRICO | 4058 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8991012 | L02 - Piano Secondo ELETTRICO | 4060 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8991053 | L02 - Piano Secondo ELETTRICO | 4062 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8991273 | L02 - Piano Secondo ELETTRICO | 4064 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8991319 | L02 - Piano Secondo ELETTRICO | 4066 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8998899 | L02 - Piano Secondo ELETTRICO | 4121 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8999005 | L02 - Piano Secondo ELETTRICO | 4123 | 0.721132 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8999027 | L02 - Piano Secondo ELETTRICO | 4125 | 0.693126 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8999271 | L02 - Piano Secondo ELETTRICO | 4127 | 0.653062 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
8999293 | L02 - Piano Secondo ELETTRICO | 4129 | 0.6928 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9245771 | L00 - Piano Terra Piazza ELETTRICO | 4166 | 0.511318 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9245908 | L00 - Piano Terra Piazza ELETTRICO | 4167 | 0.511318 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Prese:EFX_I_Unel+BipassoIp55 (10)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Frutto
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Prese; Tipologia presa: 07 - Unel + Bipasso IP55
Type - Dati identità - Commenti sul tipo: 1; Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_Unel+BipassoIp55; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 120 V
Type - Grafica - Simbolo: 07
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Unel+BipassoIp55
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Unel+BipassoIp55
Material: Frutto, Placca
Altro - Famiglia: Prese: EFX_I_Unel+BipassoIp55; Famiglia e tipo: Prese: EFX_I_Unel+BipassoIp55; ID tipo: Prese: EFX_I_Unel+BipassoIp55; Tipo: Prese: EFX_I_Unel+BipassoIp55
Dimensioni - Area: 0.0233356 m2; Volume: 0.00012899 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-200 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m
Name (Prese:EFX_I_Unel+BipassoIp55:...) | Contrassegno | Distanza_simbolo (m) | Host | Quota altimetrica da livello (m)
9891259 | 4538 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.1 | Dati identità - Commenti: Aula magna
9891934 | 4542 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9892319 | 4543 | 0.49046 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
