Properties of the parts of a building model (IFC4), part 1 of 23

# File
Description: ViewDefinition [ReferenceView_V1.2]
Time: 2022-12-10T20:45:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.70.21 - Exporter 21.1.70.21 - Alternate UI 21.1.70.21
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Dec 10 20:45:32 2022 * Host: DESKTOP-49775N7 * Database: C:\Users\FAMIGL~1\AppData\Local\Temp\abb016a5-3377-41a8-858a-ed22bbc0bd0d\0711ecf8-2e00-48c2-8a3c-31e35f22020d\ifc * Database version: 5507 * Database creation date: Sat Dec 10 20:43:22 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Sat Dec 10 20:43:22 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Dec 10 20:43:22 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: Realizzazione della nuova sede del Dipartimento di Psicologia e Amministrazione del Campus - Cesena; Phase: IMPIANTI ELETTRICI
InfoProgetto - UBO_NomeProgetto: Realizzazione della nuova sede del Dipartimento di Psicologia e Amministrazione del Campus - Cesena; UBO_FaseProgettuale: Progetto Definitivo; UBO_ProprietàEdificio: Università di Bologna con diritto di superficie gratuito dal Comune di Cesena; UBO_CodiceEdificio: 6441; UBO_Cup: J17B15000380001; UBO_NumeroTicket: 25838; UBO_Dirigente: Dott.sa Evarita D'Archivio; UBO_Rup: Dott. Ing. Enrico Benagli; UBO_ProgettistaARNome01: Geom. Ivan Nisi; UBO_ProgettistaIMNome01: Ing. Paolo Chierici; UBO_ProgettistaIENome01: Ing. Paolo Chierici; UBO_ProgettistaSTNome01: Ing. Claudio Gentili; UBO_ProgettistaAltroNome01: Ing. Lorenzo Orlandi; UBO_CspNome01: Ing. Andrea Bassi

# IfcSite, Default
RefLatitude: 44, 8, 43, 773179; RefLongitude: 12, 14, 7, 406376; RefElevation: 28.156 m
Pset_SiteCommon - Reference: Informazioni sul progetto
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: NOVEMBRE 2018; Nome del progetto: Realizzazione della nuova sede del Dipartimento di Psicologia e Amministrazione del Campus - Cesena; Stato del progetto: IMPIANTI ELETTRICI
Dati - UBO_CodiceEdificio: 6441; UBO_CspNome01: Ing. Andrea Bassi; UBO_Cup: J17B15000380001; UBO_Dirigente: Dott.sa Evarita D'Archivio; UBO_FaseProgettuale: Progetto Definitivo; UBO_NomeProgetto: Realizzazione della nuova sede del Dipartimento di Psicologia e Amministrazione del Campus - Cesena; UBO_NumeroTicket: 25838; UBO_ProgettistaAltroNome01: Ing. Lorenzo Orlandi; UBO_ProgettistaARNome01: Geom. Ivan Nisi; UBO_ProgettistaIENome01: Ing. Paolo Chierici; UBO_ProgettistaIMNome01: Ing. Paolo Chierici; UBO_ProgettistaSTNome01: Ing. Claudio Gentili; UBO_ProprietàEdificio: Università di Bologna con diritto di superficie gratuito dal Comune di Cesena; UBO_Rup: Dott. Ing. Enrico Benagli
Dati identità - Nome edificio: Università di Bologna con diritto di Superficie gratuito dal Comune di Cesena atto del 15-06-2020 REP. 12752 Racc 8952-registrato 22/06/2020 n .4320-trascritto il 22/06/2020 reg gen. 8483; Nome organizzazione: Alma Mater Studiorum Universita di Bologna Area Edilizia e Sostenibilità
Elettrico - EG_Cartella di progetto: C:\Users\faderico.gasperini\Documents\EGlink\; EG_Progetto Ampère: 956-E-Progetto elettrico-centrale_faderico.gasperini

# IfcBuilding, Università di Bologna con diritto di Superficie gratuito dal Comune di Cesena atto del 15-06-2020 REP. 12752 Racc 8952-registrato 22/06/2020 n .4320-trascritto il 22/06/2020 reg gen. 8483
LongName: Università di Bologna con diritto di Superficie gratuito dal Comune di Cesena atto del 15-06-2020 REP. 12752 Racc 8952-registrato 22/06/2020 n .4320-trascritto il 22/06/2020 reg gen. 8483
Pset_BuildingCommon - Reference: Informazioni sul progetto; NumberOfStoreys: 5
Pset_BuildingElementProxyCommon - Reference: Informazioni sul progetto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informazioni sul progetto; sets with these values: 2
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: NOVEMBRE 2018; Nome del progetto: Realizzazione della nuova sede del Dipartimento di Psicologia e Amministrazione del Campus - Cesena; Stato del progetto: IMPIANTI ELETTRICI
Dati - UBO_CodiceEdificio: 6441; UBO_CspNome01: Ing. Andrea Bassi; UBO_Cup: J17B15000380001; UBO_Dirigente: Dott.sa Evarita D'Archivio; UBO_FaseProgettuale: Progetto Definitivo; UBO_NomeProgetto: Realizzazione della nuova sede del Dipartimento di Psicologia e Amministrazione del Campus - Cesena; UBO_NumeroTicket: 25838; UBO_ProgettistaAltroNome01: Ing. Lorenzo Orlandi; UBO_ProgettistaARNome01: Geom. Ivan Nisi; UBO_ProgettistaIENome01: Ing. Paolo Chierici; UBO_ProgettistaIMNome01: Ing. Paolo Chierici; UBO_ProgettistaSTNome01: Ing. Claudio Gentili; UBO_ProprietàEdificio: Università di Bologna con diritto di superficie gratuito dal Comune di Cesena; UBO_Rup: Dott. Ing. Enrico Benagli
Dati identità - Nome edificio: Università di Bologna con diritto di Superficie gratuito dal Comune di Cesena atto del 15-06-2020 REP. 12752 Racc 8952-registrato 22/06/2020 n .4320-trascritto il 22/06/2020 reg gen. 8483; Nome organizzazione: Alma Mater Studiorum Universita di Bologna Area Edilizia e Sostenibilità
Elettrico - EG_Cartella di progetto: C:\Users\faderico.gasperini\Documents\EGlink\; EG_Progetto Ampère: 956-E-Progetto elettrico-centrale_faderico.gasperini

# IfcBuildingStorey: Livello:Estremità 8 mm (5)
In: Università di Bologna con diritto di Superficie gratuito dal Comune di Cesena atto del 15-06-2020 REP. 12752 Racc 8952-registrato 22/06/2020 n .4320-trascritto il 22/06/2020 reg gen. 8483
Vincoli(Type) - Base quota altimetrica: Punto rilevamento
Grafica(Type) - Colore: 8421504; Modello di linea: Centro; Simbolo: Estremità del livello - Triangolo 2mm: R 2; Simbolo a estremità 1 per default: yes; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Pset_BuildingStoreyCommon - Reference: Estremità 8 mm
Altro - Categoria: Livelli; Famiglia: Livello: Estremità 8 mm; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: Livello: Estremità 8 mm; Tipo: Livello: Estremità 8 mm
Dati identità - Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Name | LongName | Elevation (m) | Nome | Piano edificio | Quota altimetrica (m)
B01 - Piano Interrato ELETTRICO | B01 - Piano Interrato ELETTRICO | -0.57 | QR_Magrone | no | 26.286
L00 - Piano Terra Piazza ELETTRICO | L00 - Piano Terra Piazza ELETTRICO | 2.93 | L00 - Piano Terra Piazza ELETTRICO | yes | 31.086
L02 - Piano Secondo ELETTRICO | L02 - Piano Secondo ELETTRICO | 13.63 | L02 - Piano Secondo ELETTRICO | yes | 41.786
L03 - Piano Terzo ELETTRICO | L03 - Piano Terzo ELETTRICO | 17.78 | L03 - Piano Terzo ELETTRICO | yes | 45.936
L04 - Piano Copertura ELETTRICO | L04 - Piano Copertura ELETTRICO | 18.106 | L04 - Piano Copertura ELETTRICO | yes | 46.262

# IfcAlarm: Dispositivo manuale allarme incendio:DFA_I_DispositivoManualeAllarmeIncendio (41)
Type - Material: Spia pulsante manuale antincendio
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Dispositivo manuale allarme incendio; Tipologia: 01 - Pulsante manuale
Type - Dati identità - Commenti sul tipo: Rivelazione fumi; Label: GFCI; Nome del tipo: DFA_I_DispositivoManualeAllarmeIncendio; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 1.1 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_DispositivoManualeAllarmeIncendio
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_DispositivoManualeAllarmeIncendio
Material: Spia pulsante manuale antincendio, Black, Parte rossa, Simboli, Parte bianca
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Dispositivo manuale allarme incendio: DFA_I_DispositivoManualeAllarmeIncendio; Famiglia e tipo: Dispositivo manuale allarme incendio: DFA_I_DispositivoManualeAllarmeIncendio; ID tipo: Dispositivo manuale allarme incendio: DFA_I_DispositivoManualeAllarmeIncendio; Tipo: Dispositivo manuale allarme incendio: DFA_I_DispositivoManualeAllarmeIncendio
Dimensioni - Volume: 0.000422589 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Name (Dispositivo manuale allarme incendio:DFA_I_DispositivoManualeAllarmeIncendio:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
9253824 | L00 - Piano Terra Piazza ELETTRICO | 2350 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9254616 | B01 - Piano Interrato ELETTRICO | 2353 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
9254991 | B01 - Piano Interrato ELETTRICO | 2355 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | -0.0329529 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
9255100 | B01 - Piano Interrato ELETTRICO | 2356 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | 0.0168645 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
9255579 | B01 - Piano Interrato ELETTRICO | 2358 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | -0.0396076 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
9255599 | B01 - Piano Interrato ELETTRICO | 2359 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | 0.0168645 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
9255777 | B01 - Piano Interrato ELETTRICO | 2360 | 0.30586 | Livello: B01 - Piano Interrato ELETTRICO | 0.0168645 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
9256057 | B01 - Piano Interrato ELETTRICO | 2361 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | 0.0168645 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
9256220 | B01 - Piano Interrato ELETTRICO | 2362 | 0.5 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Dispositivo ottico acustico allarme incendio : DFA_I_DispositivoOtticoAcusticoAllarmeIncendio | 1.2
9258402 | L00 - Piano Terra Piazza ELETTRICO | 2368 | 0.038035 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
9258781 | L00 - Piano Terra Piazza ELETTRICO | 2369 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9258854 | L00 - Piano Terra Piazza ELETTRICO | 2370 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9259139 | L00 - Piano Terra Piazza ELETTRICO | 2371 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 6.80403 | <non associato> | 1
9261199 | L00 - Piano Terra Piazza ELETTRICO | 2377 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9261228 | L00 - Piano Terra Piazza ELETTRICO | 2378 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9261369 | L00 - Piano Terra Piazza ELETTRICO | 2379 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9262268 | L00 - Piano Terra Piazza ELETTRICO | 2380 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9262339 | L00 - Piano Terra Piazza ELETTRICO | 2381 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9262499 | L00 - Piano Terra Piazza ELETTRICO | 2382 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9262632 | L00 - Piano Terra Piazza ELETTRICO | 2383 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9264619 | L00 - Piano Terra Piazza ELETTRICO | 2391 | 0.25438 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9264664 | L00 - Piano Terra Piazza ELETTRICO | 2392 | 0 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9264854 | L00 - Piano Terra Piazza ELETTRICO | 2393 | 0.26719 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9265031 | L00 - Piano Terra Piazza ELETTRICO | 2394 | 0.232419 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9266927 | L00 - Piano Terra Piazza ELETTRICO | 2399 | 0 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9266936 | L00 - Piano Terra Piazza ELETTRICO | 2400 | 0.183971 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9268783 | L00 - Piano Terra Piazza ELETTRICO | 2405 | 0.354306 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9268801 | L00 - Piano Terra Piazza ELETTRICO | 2406 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9269480 | L00 - Piano Terra Piazza ELETTRICO | 2409 | 0.300864 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9269495 | L00 - Piano Terra Piazza ELETTRICO | 2410 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9269602 | L00 - Piano Terra Piazza ELETTRICO | 2411 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9269772 | L00 - Piano Terra Piazza ELETTRICO | 2412 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9271451 | L00 - Piano Terra Piazza ELETTRICO | 2417 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9271493 | L00 - Piano Terra Piazza ELETTRICO | 2418 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9271761 | L00 - Piano Terra Piazza ELETTRICO | 2419 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9273205 | L02 - Piano Secondo ELETTRICO | 2423 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9273234 | L02 - Piano Secondo ELETTRICO | 2424 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9273559 | L02 - Piano Secondo ELETTRICO | 2425 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9273995 | L02 - Piano Secondo ELETTRICO | 2426 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9274282 | L02 - Piano Secondo ELETTRICO | 2427 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1
9274516 | L02 - Piano Secondo ELETTRICO | 2428 | 0.129311 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.1

# IfcAlarm: Dispositivo ottico acustico allarme GASrfa:DFA_I_DispositivoOtticoAcusticoAllarmeGas (5)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Parte interna
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Dispositivo ottico acustico allarme GASrfa; Tipologia: 01 - Dispositivo ottico acustico
Type - Dati identità - Commenti sul tipo: Rivelazione fumi; Label: GFCI; Nome del tipo: DFA_I_DispositivoOtticoAcusticoAllarmeGas; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 2.2 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_DispositivoOtticoAcusticoAllarmeGas
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_DispositivoOtticoAcusticoAllarmeGas
Material: Parte interna, Involucro esterno, Scritta
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Dispositivo ottico acustico allarme GASrfa: DFA_I_DispositivoOtticoAcusticoAllarmeGas; Famiglia e tipo: Dispositivo ottico acustico allarme GASrfa: DFA_I_DispositivoOtticoAcusticoAllarmeGas; ID tipo: Dispositivo ottico acustico allarme GASrfa: DFA_I_DispositivoOtticoAcusticoAllarmeGas; Tipo: Dispositivo ottico acustico allarme GASrfa: DFA_I_DispositivoOtticoAcusticoAllarmeGas
Dimensioni - Volume: 0.000416269 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m
Name (Dispositivo ottico acustico allarme GASrfa:DFA_I_DispositivoOtticoAcusticoAllarmeGas:...) | Contrassegno | Distanza_simbolo (m) | Host | Quota altimetrica da livello (m)
9761504 | 2635 | 0.934633 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.954
9761645 | 2636 | 0.111291 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.7
9761791 | 2637 | 0.0516098 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.8
9764142 | 2638 | 0.0934702 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.3
9764321 | 2639 | 0.149499 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.3

# IfcAlarm: Dispositivo ottico acustico allarme incendio:DFA_I_DispositivoOtticoAcusticoAllarmeIncendio (41)
Type - Material: Parte interna
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Dispositivo ottico acustico allarme incendio; Tipologia: 01 - Dispositivo ottico acustico
Type - Dati identità - Commenti sul tipo: Rivelazione fumi; Label: GFCI; Nome del tipo: DFA_I_DispositivoOtticoAcusticoAllarmeIncendio; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 2.2 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_DispositivoOtticoAcusticoAllarmeIncendio
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_DispositivoOtticoAcusticoAllarmeIncendio
Material: Parte interna, Involucro esterno, Scritta
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Dispositivo ottico acustico allarme incendio: DFA_I_DispositivoOtticoAcusticoAllarmeIncendio; Famiglia e tipo: Dispositivo ottico acustico allarme incendio: DFA_I_DispositivoOtticoAcusticoAllarmeIncendio; ID tipo: Dispositivo ottico acustico allarme incendio: DFA_I_DispositivoOtticoAcusticoAllarmeIncendio; Tipo: Dispositivo ottico acustico allarme incendio: DFA_I_DispositivoOtticoAcusticoAllarmeIncendio
Dimensioni - Volume: 0.000421116 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Name (Dispositivo ottico acustico allarme incendio:DFA_I_DispositivoOtticoAcusticoAllarmeIncendio:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
9253928 | L00 - Piano Terra Piazza ELETTRICO | 2351 | 1.18759 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9254082 | B01 - Piano Interrato ELETTRICO | 2352 | 1.25616 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.4
9254830 | B01 - Piano Interrato ELETTRICO | 2354 | 1.25616 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.4
9255336 | B01 - Piano Interrato ELETTRICO | 2357 | 1.19574 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9256553 | B01 - Piano Interrato ELETTRICO | 2363 | 1.20819 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.3
9256776 | B01 - Piano Interrato ELETTRICO | 2364 | 1.22166 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.3
9257274 | B01 - Piano Interrato ELETTRICO | 2365 | 0.958559 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2
9257500 | B01 - Piano Interrato ELETTRICO | 2366 | 1.28357 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.7
9257988 | B01 - Piano Interrato ELETTRICO | 2367 | 1.29666 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.8
9259915 | L00 - Piano Terra Piazza ELETTRICO | 2373 | 1.1826 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9260237 | L00 - Piano Terra Piazza ELETTRICO | 2374 | 1.22361 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9260618 | L00 - Piano Terra Piazza ELETTRICO | 2375 | 1.28596 | Livello: L00 - Piano Terra Piazza ELETTRICO | 6.80403 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.2
9260964 | L00 - Piano Terra Piazza ELETTRICO | 2376 | 0.776259 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9263152 | L00 - Piano Terra Piazza ELETTRICO | 2384 | 1.27236 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9263328 | L00 - Piano Terra Piazza ELETTRICO | 2385 | 1.24102 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9263414 | L00 - Piano Terra Piazza ELETTRICO | 2386 | 1.23682 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9263809 | L00 - Piano Terra Piazza ELETTRICO | 2387 | 1.20339 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9264109 | L00 - Piano Terra Piazza ELETTRICO | 2388 | 1.19278 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9264238 | L00 - Piano Terra Piazza ELETTRICO | 2389 | 1.21384 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9264510 | L00 - Piano Terra Piazza ELETTRICO | 2390 | 1.21775 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9265694 | L00 - Piano Terra Piazza ELETTRICO | 2395 | 0.655753 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9265759 | L00 - Piano Terra Piazza ELETTRICO | 2396 | 0.949199 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9265988 | L00 - Piano Terra Piazza ELETTRICO | 2397 | 0.92589 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9266121 | L00 - Piano Terra Piazza ELETTRICO | 2398 | 0.989354 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9267428 | L00 - Piano Terra Piazza ELETTRICO | 2402 | 0.901539 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9267678 | L00 - Piano Terra Piazza ELETTRICO | 2403 | 0.707007 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9269035 | L00 - Piano Terra Piazza ELETTRICO | 2407 | 1.19672 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9269133 | L00 - Piano Terra Piazza ELETTRICO | 2408 | 1.03445 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9270415 | L00 - Piano Terra Piazza ELETTRICO | 2413 | 1.18579 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9270667 | L00 - Piano Terra Piazza ELETTRICO | 2414 | 0.964809 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9271061 | L00 - Piano Terra Piazza ELETTRICO | 2415 | 1.23849 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9271150 | L00 - Piano Terra Piazza ELETTRICO | 2416 | 1.19227 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9272710 | L00 - Piano Terra Piazza ELETTRICO | 2420 | 1.20848 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9272783 | L00 - Piano Terra Piazza ELETTRICO | 2421 | 1.22625 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9272923 | L00 - Piano Terra Piazza ELETTRICO | 2422 | 1.18301 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9275335 | L02 - Piano Secondo ELETTRICO | 2430 | 1.23691 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9275420 | L02 - Piano Secondo ELETTRICO | 2431 | 1.22661 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9275506 | L02 - Piano Secondo ELETTRICO | 2432 | 1.2268 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9275543 | L02 - Piano Secondo ELETTRICO | 2433 | 1.21646 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9275875 | L02 - Piano Secondo ELETTRICO | 2434 | 1.17935 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3
9276046 | L02 - Piano Secondo ELETTRICO | 2435 | 0.80645 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.3

# IfcAlarm: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED:DFA_I_RivelatoreFumiASoffitto (190)
Type - Classification: D5030700 Fire Alarm Systems (Uniformat); Material: High Impact Polymer - UTC - White
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED
Type - Dati - Agency Listings: CAN/ULC-S529, UL 268, UL 268A; Alarm Point: Analyzes data from the sensing chamber to determine whether to alarm; Environmental Compensation: Automatic; Mounting Information: Plug-in, Maximum 12 in (305mm) from ceiling; Spacing: N/A; Storage and Operating Environment: Air Velocity: 0 to 4000 ft/min (0 to 20 m/s); Operating Temperature: 32°F to 120°F (0°C to 49°C); Storage Temperature: -4°F to 140°F (-20°C to 60°C); Humidity: 0 to 93% RH, Non-Condensing
Type - Dati identità - Codice assieme: D5030700; Commenti sul tipo: Rivelazione fumi; Copyright: Copyright © UTC Climate, Controls & Security; Date Last Modified: November 16, 2017; Descrizione: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Descrizione assieme: Fire Alarm Systems; Equipment Abbreviation: FS; Family Version: 1.0.0; Model Disclaimer: Contact UTC Climate, Controls & Security for more information.; Modello: SIGA-PD w/ SIGA-SB base; Nome del tipo: DFA_I_RivelatoreFumiASoffitto; Numero OmniClass: 23.85.30.21.11; Original Creation Date: November 16, 2017; Product data url: https://bimobject.com/edwardsutc/product/edwards-utc-85001-0622; Product Documentation Link: https://myeddie.edwardsutcfs.com/Media/Catalog%20Sheets/E85001-0646%20--%20Intelligent%20Smoke%20Detector.pdf; Product Page URL: https://myeddie.edwardsutcfs.com/Products/ProductSearch?SearchTerm=SIGA-PD; Product url: http://edwardsfiresafety.com/; Produttore: UTC Climate, Controls & Security; Provide Feedback: https://www.surveymonkey.com/s/XQB9QDX; Technical description: http://edwards-es.com/Data%20Sheets/8%20--%20Intelligent%20Initiating/E85001-0622%20--%20Intelligent%20Carbon%20Monoxide%20Detector.pdf; Titolo OmniClass: Fire Detection, Monitoring and Alarm; URL: http://www.edwardsfiresafety.com/
Type - Dimensioni - Below Surface Depth: 0 m; Base Depth: 0.018796 m; Base Diameter: 0.112014 m; Detector Depth: 0.0588264 m; Detector Diameter: 0.109195 m
Type - Elettrico - Operating Current: 0.000032 A; Operating Voltage: 19.95 V
Type - Generale - Edition number: 1; Nominal height: 0 m; Nominal width: 0 m; Brand url: http://www.edwardsfiresafety.com/; Date of publishing: 7/3/2013; Design country: United States; Manufacturer country: China; Manufacturer name: Edwards UTC; Product family: Electronics; Product group: Fire/Smoke Detectors; Product SKU: edwards-utc-85001-0622; QR code: http://bimobject.com/edwardsutc/product/edwards-utc-85001-0622; Region North America: US; Weight Net (Kg): 0
Type - Materiali e finiture - Housing Material: High Impact Polymer - UTC - White; Material main: Plastic
Type - Proprietà modello - Base Option: SIGA-SB; Detector is for Candadian Markets: no; Detector Option: Photo
Type - Strutturale - Weight: 0.00266893 kN
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_AlarmTypeCommon - Reference: DFA_I_RivelatoreFumiASoffitto
Type - Pset_EnvironmentalImpactIndicators - Reference: DFA_I_RivelatoreFumiASoffitto
Type - Pset_ManufacturerTypeInformation - Manufacturer: UTC Climate, Controls & Security
Pset_AlarmTypeCommon - sets with these values: 2
Altro - Famiglia: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED: DFA_I_RivelatoreFumiASoffitto; Famiglia e tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED: DFA_I_RivelatoreFumiASoffitto; ID tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED: DFA_I_RivelatoreFumiASoffitto; Tipo: Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED: DFA_I_RivelatoreFumiASoffitto
Dati identità - Part Description: The Signature Series model SIGA-PD Intelligent Photoelectric Smoke Detector is an intelligent device that uses an optical sensing chamber to detect smoke; Part Number: SIGA-PD w/ SIGA-SB base
Dimensioni - Volume: 0.000566744 m3
Fasi - Fase di creazione: Nuova costruzione
Name (Fire_Alarm-Intelligent_Detector-EDWARDS-CO-Detectors-with-LED:DFA_I_RivelatoreFumiASoffitto:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9007960 | L00 - Piano Terra Piazza ELETTRICO | 2107 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009131 | L00 - Piano Terra Piazza ELETTRICO | 2126 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009141 | L00 - Piano Terra Piazza ELETTRICO | 2127 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009149 | L00 - Piano Terra Piazza ELETTRICO | 2128 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009161 | L00 - Piano Terra Piazza ELETTRICO | 2129 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009177 | L00 - Piano Terra Piazza ELETTRICO | 2130 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9009196 | L00 - Piano Terra Piazza ELETTRICO | 2131 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9014671 | L02 - Piano Secondo ELETTRICO | 2243 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9014712 | L02 - Piano Secondo ELETTRICO | 2244 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3.94
9342630 | L02 - Piano Secondo ELETTRICO | 2445 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342703 | L02 - Piano Secondo ELETTRICO | 2446 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3.94
9342717 | L02 - Piano Secondo ELETTRICO | 2447 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342733 | L02 - Piano Secondo ELETTRICO | 2448 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342747 | L02 - Piano Secondo ELETTRICO | 2449 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342755 | L02 - Piano Secondo ELETTRICO | 2450 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342768 | L02 - Piano Secondo ELETTRICO | 2451 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342781 | L02 - Piano Secondo ELETTRICO | 2452 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3.94
9342810 | L02 - Piano Secondo ELETTRICO | 2453 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342823 | L02 - Piano Secondo ELETTRICO | 2454 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342833 | L02 - Piano Secondo ELETTRICO | 2455 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342849 | L02 - Piano Secondo ELETTRICO | 2456 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342911 | L02 - Piano Secondo ELETTRICO | 2457 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342922 | L02 - Piano Secondo ELETTRICO | 2458 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342935 | L02 - Piano Secondo ELETTRICO | 2459 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342945 | L02 - Piano Secondo ELETTRICO | 2460 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9342961 | L02 - Piano Secondo ELETTRICO | 2461 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343008 | L02 - Piano Secondo ELETTRICO | 2462 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343034 | L02 - Piano Secondo ELETTRICO | 2463 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343045 | L02 - Piano Secondo ELETTRICO | 2464 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343055 | L02 - Piano Secondo ELETTRICO | 2465 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343065 | L02 - Piano Secondo ELETTRICO | 2466 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343087 | L02 - Piano Secondo ELETTRICO | 2467 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343098 | L02 - Piano Secondo ELETTRICO | 2468 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343141 | L02 - Piano Secondo ELETTRICO | 2469 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343148 | L02 - Piano Secondo ELETTRICO | 2470 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343202 | L02 - Piano Secondo ELETTRICO | 2471 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343215 | L02 - Piano Secondo ELETTRICO | 2472 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343225 | L02 - Piano Secondo ELETTRICO | 2473 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343241 | L02 - Piano Secondo ELETTRICO | 2474 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343280 | L02 - Piano Secondo ELETTRICO | 2475 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343303 | L02 - Piano Secondo ELETTRICO | 2476 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343403 | L02 - Piano Secondo ELETTRICO | 2477 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343424 | L02 - Piano Secondo ELETTRICO | 2478 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343461 | L02 - Piano Secondo ELETTRICO | 2479 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343489 | L02 - Piano Secondo ELETTRICO | 2480 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343551 | L02 - Piano Secondo ELETTRICO | 2481 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343580 | L02 - Piano Secondo ELETTRICO | 2482 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343600 | L02 - Piano Secondo ELETTRICO | 2483 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343637 | L02 - Piano Secondo ELETTRICO | 2484 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343647 | L02 - Piano Secondo ELETTRICO | 2485 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343675 | L02 - Piano Secondo ELETTRICO | 2486 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343688 | L02 - Piano Secondo ELETTRICO | 2487 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343776 | L02 - Piano Secondo ELETTRICO | 2488 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343787 | L02 - Piano Secondo ELETTRICO | 2489 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343833 | L02 - Piano Secondo ELETTRICO | 2490 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343852 | L02 - Piano Secondo ELETTRICO | 2491 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9343877 | L02 - Piano Secondo ELETTRICO | 2492 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9344006 | L02 - Piano Secondo ELETTRICO | 2493 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9344557 | L00 - Piano Terra Piazza ELETTRICO | 2494 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344577 | L00 - Piano Terra Piazza ELETTRICO | 2495 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344596 | L00 - Piano Terra Piazza ELETTRICO | 2496 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344633 | L00 - Piano Terra Piazza ELETTRICO | 2497 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344688 | L00 - Piano Terra Piazza ELETTRICO | 2498 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344702 | L00 - Piano Terra Piazza ELETTRICO | 2499 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344721 | L00 - Piano Terra Piazza ELETTRICO | 2500 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344735 | L00 - Piano Terra Piazza ELETTRICO | 2501 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344812 | L00 - Piano Terra Piazza ELETTRICO | 2502 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344832 | L00 - Piano Terra Piazza ELETTRICO | 2503 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344854 | L00 - Piano Terra Piazza ELETTRICO | 2504 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344872 | L00 - Piano Terra Piazza ELETTRICO | 2505 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344968 | L00 - Piano Terra Piazza ELETTRICO | 2506 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9344982 | L00 - Piano Terra Piazza ELETTRICO | 2507 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345003 | L00 - Piano Terra Piazza ELETTRICO | 2508 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345023 | L00 - Piano Terra Piazza ELETTRICO | 2509 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345103 | L00 - Piano Terra Piazza ELETTRICO | 2510 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345158 | L00 - Piano Terra Piazza ELETTRICO | 2511 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345181 | L00 - Piano Terra Piazza ELETTRICO | 2512 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345191 | L00 - Piano Terra Piazza ELETTRICO | 2513 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345205 | L00 - Piano Terra Piazza ELETTRICO | 2514 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 4.15
9345219 | L00 - Piano Terra Piazza ELETTRICO | 2515 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345233 | L00 - Piano Terra Piazza ELETTRICO | 2516 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345244 | L00 - Piano Terra Piazza ELETTRICO | 2517 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345254 | L00 - Piano Terra Piazza ELETTRICO | 2518 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345268 | L00 - Piano Terra Piazza ELETTRICO | 2519 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345281 | L00 - Piano Terra Piazza ELETTRICO | 2520 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345291 | L00 - Piano Terra Piazza ELETTRICO | 2521 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345301 | L00 - Piano Terra Piazza ELETTRICO | 2522 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345321 | L00 - Piano Terra Piazza ELETTRICO | 2523 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9345329 | L00 - Piano Terra Piazza ELETTRICO | 2524 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9345342 | L00 - Piano Terra Piazza ELETTRICO | 2525 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9345445 | L00 - Piano Terra Piazza ELETTRICO | 2526 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345461 | L00 - Piano Terra Piazza ELETTRICO | 2527 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345482 | L00 - Piano Terra Piazza ELETTRICO | 2528 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345496 | L00 - Piano Terra Piazza ELETTRICO | 2529 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345510 | L00 - Piano Terra Piazza ELETTRICO | 2530 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345523 | L00 - Piano Terra Piazza ELETTRICO | 2531 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345536 | L00 - Piano Terra Piazza ELETTRICO | 2532 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345555 | L00 - Piano Terra Piazza ELETTRICO | 2533 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345580 | L00 - Piano Terra Piazza ELETTRICO | 2534 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9345598 | L00 - Piano Terra Piazza ELETTRICO | 2535 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345769 | L00 - Piano Terra Piazza ELETTRICO | 2536 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345794 | L00 - Piano Terra Piazza ELETTRICO | 2537 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345813 | L00 - Piano Terra Piazza ELETTRICO | 2538 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345826 | L00 - Piano Terra Piazza ELETTRICO | 2539 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.15
9345842 | L00 - Piano Terra Piazza ELETTRICO | 2540 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346091 | L00 - Piano Terra Piazza ELETTRICO | 2541 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9346111 | L00 - Piano Terra Piazza ELETTRICO | 2542 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9346133 | L00 - Piano Terra Piazza ELETTRICO | 2543 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9346147 | L00 - Piano Terra Piazza ELETTRICO | 2544 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.25
9346187 | L00 - Piano Terra Piazza ELETTRICO | 2545 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 4.25
9346212 | L00 - Piano Terra Piazza ELETTRICO | 2546 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9346220 | L00 - Piano Terra Piazza ELETTRICO | 2547 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9346236 | L00 - Piano Terra Piazza ELETTRICO | 2548 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 4.25
9346659 | L00 - Piano Terra Piazza ELETTRICO | 2549 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346679 | L00 - Piano Terra Piazza ELETTRICO | 2550 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346721 | L00 - Piano Terra Piazza ELETTRICO | 2551 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346732 | L00 - Piano Terra Piazza ELETTRICO | 2552 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346763 | L00 - Piano Terra Piazza ELETTRICO | 2553 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346776 | L00 - Piano Terra Piazza ELETTRICO | 2554 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346814 | L00 - Piano Terra Piazza ELETTRICO | 2555 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9346828 | L00 - Piano Terra Piazza ELETTRICO | 2556 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
9347061 | L00 - Piano Terra Piazza ELETTRICO | 2557 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347071 | L00 - Piano Terra Piazza ELETTRICO | 2558 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4.65
9347086 | L00 - Piano Terra Piazza ELETTRICO | 2559 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347102 | L00 - Piano Terra Piazza ELETTRICO | 2560 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347120 | L00 - Piano Terra Piazza ELETTRICO | 2561 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347135 | L00 - Piano Terra Piazza ELETTRICO | 2562 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347226 | L00 - Piano Terra Piazza ELETTRICO | 2563 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347241 | L00 - Piano Terra Piazza ELETTRICO | 2564 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347256 | L00 - Piano Terra Piazza ELETTRICO | 2565 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347307 | L00 - Piano Terra Piazza ELETTRICO | 2566 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347329 | L00 - Piano Terra Piazza ELETTRICO | 2567 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347393 | L00 - Piano Terra Piazza ELETTRICO | 2568 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9347826 | L00 - Piano Terra Piazza ELETTRICO | 2569 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4.75
9347907 | L00 - Piano Terra Piazza ELETTRICO | 2570 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9348019 | L00 - Piano Terra Piazza ELETTRICO | 2571 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9348104 | L00 - Piano Terra Piazza ELETTRICO | 2572 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9348252 | L00 - Piano Terra Piazza ELETTRICO | 2573 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9348511 | L00 - Piano Terra Piazza ELETTRICO | 2574 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9348765 | L00 - Piano Terra Piazza ELETTRICO | 2575 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9348851 | L00 - Piano Terra Piazza ELETTRICO | 2576 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9348912 | L00 - Piano Terra Piazza ELETTRICO | 2577 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9348962 | L00 - Piano Terra Piazza ELETTRICO | 2578 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9349004 | L00 - Piano Terra Piazza ELETTRICO | 2579 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9349093 | L00 - Piano Terra Piazza ELETTRICO | 2580 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9349344 | L00 - Piano Terra Piazza ELETTRICO | 2581 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9349449 | L00 - Piano Terra Piazza ELETTRICO | 2582 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9349524 | L00 - Piano Terra Piazza ELETTRICO | 2583 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9349549 | L00 - Piano Terra Piazza ELETTRICO | 2584 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9349611 | L00 - Piano Terra Piazza ELETTRICO | 2585 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.65
9349885 | L00 - Piano Terra Piazza ELETTRICO | 2586 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350084 | L00 - Piano Terra Piazza ELETTRICO | 2587 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350179 | L00 - Piano Terra Piazza ELETTRICO | 2588 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350275 | L00 - Piano Terra Piazza ELETTRICO | 2589 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350376 | L00 - Piano Terra Piazza ELETTRICO | 2590 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350655 | L00 - Piano Terra Piazza ELETTRICO | 2591 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350797 | L00 - Piano Terra Piazza ELETTRICO | 2592 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350859 | L00 - Piano Terra Piazza ELETTRICO | 2593 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9350933 | L00 - Piano Terra Piazza ELETTRICO | 2594 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351177 | L00 - Piano Terra Piazza ELETTRICO | 2595 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351224 | L00 - Piano Terra Piazza ELETTRICO | 2596 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
9351292 | L00 - Piano Terra Piazza ELETTRICO | 2597 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.75
