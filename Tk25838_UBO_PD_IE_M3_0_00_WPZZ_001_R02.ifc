Properties of the parts of a building model (IFC4), part 5 of 23

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofase_Soff (112)
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Alim.NeMonofase_Soff
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Alim.NeMonofase_Soff
Material: Placca, Metallo
Altro - Famiglia: Alimentazione monofase: EFX_I_Alim.NeMonofase_Soff; Famiglia e tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase_Soff; ID tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase_Soff; Tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase_Soff
Dimensioni - Area: 0.0113601 m2; Volume: 0.0000363445 m3
Elettrico - Load: 100 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-100 W
Fasi - Fase di creazione: Nuova costruzione
Generale - Nome dispositivo: Alim.ne fancoil
Vincoli - Offset da host: 0 m
Name (Alimentazione monofase:EFX_I_Alim.NeMonofase_Soff:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9718058 | L02 - Piano Secondo ELETTRICO | 4325 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718093 | L02 - Piano Secondo ELETTRICO | 4326 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718177 | L02 - Piano Secondo ELETTRICO | 4327 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718203 | L02 - Piano Secondo ELETTRICO | 4328 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718335 | L02 - Piano Secondo ELETTRICO | 4330 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718433 | L02 - Piano Secondo ELETTRICO | 4331 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718468 | L02 - Piano Secondo ELETTRICO | 4332 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718488 | L02 - Piano Secondo ELETTRICO | 4333 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718502 | L02 - Piano Secondo ELETTRICO | 4334 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718535 | L02 - Piano Secondo ELETTRICO | 4335 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718594 | L02 - Piano Secondo ELETTRICO | 4336 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718624 | L02 - Piano Secondo ELETTRICO | 4337 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718675 | L02 - Piano Secondo ELETTRICO | 4338 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718755 | L02 - Piano Secondo ELETTRICO | 4339 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718776 | L02 - Piano Secondo ELETTRICO | 4340 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718886 | L02 - Piano Secondo ELETTRICO | 4341 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718963 | L02 - Piano Secondo ELETTRICO | 4342 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9718984 | L02 - Piano Secondo ELETTRICO | 4343 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719022 | L02 - Piano Secondo ELETTRICO | 4344 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719203 | L02 - Piano Secondo ELETTRICO | 4348 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719352 | L02 - Piano Secondo ELETTRICO | 4349 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719408 | L02 - Piano Secondo ELETTRICO | 4350 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719478 | L02 - Piano Secondo ELETTRICO | 4351 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719627 | L02 - Piano Secondo ELETTRICO | 4352 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719651 | L02 - Piano Secondo ELETTRICO | 4353 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719668 | L02 - Piano Secondo ELETTRICO | 4354 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719693 | L02 - Piano Secondo ELETTRICO | 4355 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719716 | L02 - Piano Secondo ELETTRICO | 4356 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719742 | L02 - Piano Secondo ELETTRICO | 4357 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719750 | L02 - Piano Secondo ELETTRICO | 4358 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719762 | L02 - Piano Secondo ELETTRICO | 4359 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719840 | L02 - Piano Secondo ELETTRICO | 4360 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719850 | L02 - Piano Secondo ELETTRICO | 4361 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719906 | L02 - Piano Secondo ELETTRICO | 4363 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719944 | L02 - Piano Secondo ELETTRICO | 4364 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719955 | L02 - Piano Secondo ELETTRICO | 4365 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9719990 | L02 - Piano Secondo ELETTRICO | 4366 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720192 | L02 - Piano Secondo ELETTRICO | 4367 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
9720281 | L02 - Piano Secondo ELETTRICO | 4368 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720289 | L02 - Piano Secondo ELETTRICO | 4369 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720299 | L02 - Piano Secondo ELETTRICO | 4370 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720309 | L02 - Piano Secondo ELETTRICO | 4371 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720331 | L02 - Piano Secondo ELETTRICO | 4372 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720339 | L02 - Piano Secondo ELETTRICO | 4373 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720349 | L02 - Piano Secondo ELETTRICO | 4374 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720361 | L02 - Piano Secondo ELETTRICO | 4375 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720371 | L02 - Piano Secondo ELETTRICO | 4376 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720407 | L02 - Piano Secondo ELETTRICO | 4377 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9720584 | L00 - Piano Terra Piazza ELETTRICO | 4378 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721055 | L00 - Piano Terra Piazza ELETTRICO | 4380 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9721209 | L00 - Piano Terra Piazza ELETTRICO | 4381 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9721261 | L00 - Piano Terra Piazza ELETTRICO | 4382 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9721271 | L00 - Piano Terra Piazza ELETTRICO | 4383 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9721299 | L00 - Piano Terra Piazza ELETTRICO | 4386 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9721407 | L00 - Piano Terra Piazza ELETTRICO | 4391 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9721458 | L00 - Piano Terra Piazza ELETTRICO | 4392 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721512 | L00 - Piano Terra Piazza ELETTRICO | 4393 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721546 | L00 - Piano Terra Piazza ELETTRICO | 4394 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721586 | L00 - Piano Terra Piazza ELETTRICO | 4395 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721620 | L00 - Piano Terra Piazza ELETTRICO | 4396 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721660 | L00 - Piano Terra Piazza ELETTRICO | 4397 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721698 | L00 - Piano Terra Piazza ELETTRICO | 4398 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721741 | L00 - Piano Terra Piazza ELETTRICO | 4399 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721778 | L00 - Piano Terra Piazza ELETTRICO | 4400 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721792 | L00 - Piano Terra Piazza ELETTRICO | 4401 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721851 | L00 - Piano Terra Piazza ELETTRICO | 4402 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721871 | L00 - Piano Terra Piazza ELETTRICO | 4403 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721888 | L00 - Piano Terra Piazza ELETTRICO | 4404 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721934 | L00 - Piano Terra Piazza ELETTRICO | 4405 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721948 | L00 - Piano Terra Piazza ELETTRICO | 4406 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9721987 | L00 - Piano Terra Piazza ELETTRICO | 4407 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722335 | L00 - Piano Terra Piazza ELETTRICO | 4408 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722372 | L00 - Piano Terra Piazza ELETTRICO | 4409 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722395 | L00 - Piano Terra Piazza ELETTRICO | 4410 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722430 | L00 - Piano Terra Piazza ELETTRICO | 4411 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722505 | L00 - Piano Terra Piazza ELETTRICO | 4412 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722559 | L00 - Piano Terra Piazza ELETTRICO | 4413 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722607 | L00 - Piano Terra Piazza ELETTRICO | 4414 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722608 | L00 - Piano Terra Piazza ELETTRICO | 4415 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722624 | L00 - Piano Terra Piazza ELETTRICO | 4416 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9722641 | L00 - Piano Terra Piazza ELETTRICO | 4417 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9722739 | L00 - Piano Terra Piazza ELETTRICO | 4419 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722769 | L00 - Piano Terra Piazza ELETTRICO | 4420 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722806 | L00 - Piano Terra Piazza ELETTRICO | 4421 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722820 | L00 - Piano Terra Piazza ELETTRICO | 4422 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722831 | L00 - Piano Terra Piazza ELETTRICO | 4423 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9722842 | L00 - Piano Terra Piazza ELETTRICO | 4424 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9749911 | L00 - Piano Terra Piazza ELETTRICO | 4453 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9749922 | L00 - Piano Terra Piazza ELETTRICO | 4454 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9749974 | L00 - Piano Terra Piazza ELETTRICO | 4455 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750024 | L00 - Piano Terra Piazza ELETTRICO | 4456 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750076 | L00 - Piano Terra Piazza ELETTRICO | 4457 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750114 | L00 - Piano Terra Piazza ELETTRICO | 4458 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750173 | L00 - Piano Terra Piazza ELETTRICO | 4460 | 0.0628679 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750201 | L00 - Piano Terra Piazza ELETTRICO | 4461 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750261 | L00 - Piano Terra Piazza ELETTRICO | 4462 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750367 | L00 - Piano Terra Piazza ELETTRICO | 4464 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750390 | L00 - Piano Terra Piazza ELETTRICO | 4465 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750434 | L00 - Piano Terra Piazza ELETTRICO | 4466 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750454 | L00 - Piano Terra Piazza ELETTRICO | 4467 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750483 | L00 - Piano Terra Piazza ELETTRICO | 4468 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750527 | L00 - Piano Terra Piazza ELETTRICO | 4469 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750600 | L00 - Piano Terra Piazza ELETTRICO | 4472 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750625 | L00 - Piano Terra Piazza ELETTRICO | 4473 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9750675 | L00 - Piano Terra Piazza ELETTRICO | 4474 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9750700 | L00 - Piano Terra Piazza ELETTRICO | 4475 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9750711 | L00 - Piano Terra Piazza ELETTRICO | 4476 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9750739 | L00 - Piano Terra Piazza ELETTRICO | 4477 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9750771 | L00 - Piano Terra Piazza ELETTRICO | 4478 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9750817 | L00 - Piano Terra Piazza ELETTRICO | 4479 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9750860 | L00 - Piano Terra Piazza ELETTRICO | 4480 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9750900 | L00 - Piano Terra Piazza ELETTRICO | 4481 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3

# IfcBuildingElementProxy: Alimentazione trifase:Alimentazione trifase IP55 (34)
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Alimentazione trifase; Tipologia presa: Alimentazione IP55
Type - Dati identità - Contrassegno tipo: 1; Label: GFCI; Nome del tipo: Alimentazione trifase IP55; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 03
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Alimentazione trifase IP55
Type - Pset_EnvironmentalImpactIndicators - Reference: Alimentazione trifase IP55
Material: Placca, Metallo
Altro - Famiglia: Alimentazione trifase: Alimentazione trifase IP55; Famiglia e tipo: Alimentazione trifase: Alimentazione trifase IP55; ID tipo: Alimentazione trifase: Alimentazione trifase IP55; Tipo: Alimentazione trifase: Alimentazione trifase IP55
Dimensioni - Distanza_simbolo: 0.5 m; Volume: 0.000677614 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 400 V/3-0 W
Fasi - Fase di creazione: Nuova costruzione
Name (Alimentazione trifase:Alimentazione trifase IP55:...) | In | Contrassegno | Nome dispositivo | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
9753484 | B01 - Piano Interrato ELETTRICO | 4491 | Alim.ne P1-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753530 | B01 - Piano Interrato ELETTRICO | 4492 | Alim.ne P1-B | Livello: B01 - Piano Interrato ELETTRICO | 0.913409 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753567 | B01 - Piano Interrato ELETTRICO | 4493 | Alim.ne P2-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753568 | B01 - Piano Interrato ELETTRICO | 4494 | Alim.ne P2-A | Livello: B01 - Piano Interrato ELETTRICO | 0.913409 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753616 | B01 - Piano Interrato ELETTRICO | 4495 | Alim.ne P3-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753617 | B01 - Piano Interrato ELETTRICO | 4496 | Alim.ne P3-A | Livello: B01 - Piano Interrato ELETTRICO | 0.932902 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753813 | B01 - Piano Interrato ELETTRICO | 4497 | Alim.ne P4-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753820 | B01 - Piano Interrato ELETTRICO | 4498 | Alim.ne P4-A | Livello: B01 - Piano Interrato ELETTRICO | 0.928479 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9753913 | B01 - Piano Interrato ELETTRICO | 4499 | Alim.ne P5-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9754173 | B01 - Piano Interrato ELETTRICO | 4502 | Alim.ne PTLR-B | Livello: B01 - Piano Interrato ELETTRICO | 0.794648 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9754694 | B01 - Piano Interrato ELETTRICO | 4505 | Alim.ne PTLR-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9754776 | B01 - Piano Interrato ELETTRICO | 4506 | Alim.ne P6-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9754861 | B01 - Piano Interrato ELETTRICO | 4507 | Alim.ne P6-B | Livello: B01 - Piano Interrato ELETTRICO | 0.680097 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9754963 | B01 - Piano Interrato ELETTRICO | 4508 | Alim.ne P10-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755013 | B01 - Piano Interrato ELETTRICO | 4510 | Alim.ne P7-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755057 | B01 - Piano Interrato ELETTRICO | 4511 | Alim.ne P7-B | Livello: B01 - Piano Interrato ELETTRICO | 0.729637 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755124 | B01 - Piano Interrato ELETTRICO | 4512 | Alim.ne P8-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755188 | B01 - Piano Interrato ELETTRICO | 4513 | Alim.ne P8-B | Livello: B01 - Piano Interrato ELETTRICO | 0.678375 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755332 | B01 - Piano Interrato ELETTRICO | 4514 | Alim.ne P9-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755333 | B01 - Piano Interrato ELETTRICO | 4515 | Alim.ne P9-B | Livello: B01 - Piano Interrato ELETTRICO | 0.678375 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755382 | B01 - Piano Interrato ELETTRICO | 4516 | Alim.ne P12-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755403 | B01 - Piano Interrato ELETTRICO | 4517 | Alim.ne P12-B | Livello: B01 - Piano Interrato ELETTRICO | 0.756807 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755476 | B01 - Piano Interrato ELETTRICO | 4518 | Alim.ne P11-A | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755477 | B01 - Piano Interrato ELETTRICO | 4519 | Alim.ne P11-B | Livello: B01 - Piano Interrato ELETTRICO | 0.756807 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9755654 | B01 - Piano Interrato ELETTRICO | 4520 | Alim.ne P10-B | Livello: B01 - Piano Interrato ELETTRICO | 0.716685 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.5
9756111 | B01 - Piano Interrato ELETTRICO | 4521 | Alim.ne P5-B | Livello: B01 - Piano Interrato ELETTRICO | 0.674713 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9756138 | B01 - Piano Interrato ELETTRICO | 4522 | Alim.ne P5-C | Livello: B01 - Piano Interrato ELETTRICO | 1.37562 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.5
9764822 | L02 - Piano Secondo ELETTRICO | 4529 | Alim.ne UTA | Livello: L02 - Piano Secondo ELETTRICO | 0 | Collegamenti mancanti | 0.369703
9765309 | L04 - Piano Copertura ELETTRICO | 4530 | Alim.ne UTA | Livello: L04 - Piano Copertura ELETTRICO | 0 | Collegamenti mancanti | 0.333461
9765347 | L04 - Piano Copertura ELETTRICO | 4531 | Alim.ne UTA | Livello: L04 - Piano Copertura ELETTRICO | 0 | Collegamenti mancanti | 0.466909
9765435 | L04 - Piano Copertura ELETTRICO | 4532 | Alim.ne UTA | Livello: L04 - Piano Copertura ELETTRICO | -0.282843 | Collegamenti mancanti | 0.356371
9765476 | L04 - Piano Copertura ELETTRICO | 4533 | Alim.ne UTA | Livello: L04 - Piano Copertura ELETTRICO | 0 | Collegamenti mancanti | 0.356085
9765615 | L02 - Piano Secondo ELETTRICO | 4534 | Alim.ne gruppo frigo | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt | 1.67107
9765847 | L02 - Piano Secondo ELETTRICO | 4535 | Alim.ne gruppo frigo | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt | 1.32558

# IfcBuildingElementProxy: Alimentazione trifase:Alimentazione trifase IP55 UPS, Alimentazione trifase:Alimentazione trifase IP55 UPS:9891627
In: B01 - Piano Interrato ELETTRICO
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: Alimentazione IP55; Nome famiglia: Alimentazione trifase
Type - Dati identità - Commenti sul tipo: ups; Label: GFCI; Nome del tipo: Alimentazione trifase IP55 UPS; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 03
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Alimentazione trifase IP55 UPS
Type - Pset_EnvironmentalImpactIndicators - Reference: Alimentazione trifase IP55 UPS
Material: Placca, Metallo
Altro - Famiglia: Alimentazione trifase: Alimentazione trifase IP55 UPS; Famiglia e tipo: Alimentazione trifase: Alimentazione trifase IP55 UPS; ID tipo: Alimentazione trifase: Alimentazione trifase IP55 UPS; Tipo: Alimentazione trifase: Alimentazione trifase IP55 UPS
Dati identità - Commenti: Aula magna; Contrassegno: 4540
Dimensioni - Distanza_simbolo: 0.5 m; Volume: 0.000677614 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 400 V/3-0 W
Fasi - Fase di creazione: Nuova costruzione
Generale - Nome dispositivo: Alim.ne estrattore
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 0.3 m

# IfcBuildingElementProxy: Alimentazione trifase:Alimentazione trifase con neutro (2)
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Alimentazione trifase; Tipologia presa: Alimentazione
Type - Dati identità - Commenti sul tipo: 1; Contrassegno tipo: 1; Label: GFCI; Nome del tipo: Alimentazione trifase con neutro; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Alimentazione trifase con neutro
Type - Pset_EnvironmentalImpactIndicators - Reference: Alimentazione trifase con neutro
Material: Placca, Metallo
Altro - Famiglia: Alimentazione trifase: Alimentazione trifase con neutro; Famiglia e tipo: Alimentazione trifase: Alimentazione trifase con neutro; ID tipo: Alimentazione trifase: Alimentazione trifase con neutro; Tipo: Alimentazione trifase: Alimentazione trifase con neutro
Dimensioni - Distanza_simbolo: 0.5 m; Volume: 0.0000363445 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 400 V/3-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (Alimentazione trifase:Alimentazione trifase con neutro:...) | In | Contrassegno | Nome dispositivo | Livello = Livello abaco | Quota altimetrica da livello (m) | Host
9764416 | B01 - Piano Interrato ELETTRICO | 4528 | Alim.ne UTA | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10295410 | L00 - Piano Terra Piazza ELETTRICO | 4572 | Alim.ne ascensore | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Alimentazione trifase:Alimentazione trifase con neutro IP55 (16)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: Alimentazione IP55; Nome famiglia: Alimentazione trifase
Type - Dati identità - Commenti sul tipo: 1; Contrassegno tipo: 1; Label: GFCI; Nome del tipo: Alimentazione trifase con neutro IP55; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 04
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Alimentazione trifase con neutro IP55
Type - Pset_EnvironmentalImpactIndicators - Reference: Alimentazione trifase con neutro IP55
Material: Placca, Metallo
Altro - Famiglia: Alimentazione trifase: Alimentazione trifase con neutro IP55; Famiglia e tipo: Alimentazione trifase: Alimentazione trifase con neutro IP55; ID tipo: Alimentazione trifase: Alimentazione trifase con neutro IP55; Tipo: Alimentazione trifase: Alimentazione trifase con neutro IP55
Dimensioni - Distanza_simbolo: 0.5 m; Volume: 0.000677614 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 400 V/3-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m
Name (Alimentazione trifase:Alimentazione trifase con neutro IP55:...) | Contrassegno | Nome dispositivo | Host | Quota altimetrica da livello (m)
9891732 | 4541 | QE pompe di sentina | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10309979 | 4671 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10310171 | 4673 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10310333 | 4674 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10310370 | 4675 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10310381 | 4676 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10310521 | 4678 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10310628 | 4679 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10310738 | 4680 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10311375 | 4681 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10311410 | 4682 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10311545 | 4683 | Alim.ne presa auto | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10311826 | 4684 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10312020 | 4685 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10312507 | 4687 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10793328 | 5073 | Predisp. presa auto | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2

# IfcBuildingElementProxy: Ceiling_Sensor-Wireless_PIR-Hubbell_Wiring-WLP450C:WLP450C (40)
Type - Material: Plastic - Hubbell - Translucent White, Plastic - Hubbell - White
Type - Altro - Categoria: Dispositivi di sicurezza; Connector Description 1: Power Supply; Connector Description 2: Controls; Nome famiglia: Ceiling_Sensor-Wireless_PIR-Hubbell_Wiring-WLP450C
Type - Dati identità - Commenti sul tipo: SAI; Contrassegno tipo: SAI; Descrizione: Wireless Ceiling Mount Sensor; Modello: WLP450C; Nome del tipo: WLP450C; Numero OmniClass: 23.85.80.11.27; Product data url: https://bimobject.com/hubbellwiring/product/hubbell-wlp450c; Product Documentation Link: http://ecatalog.hubbell-wiring.com/productinformation/CustomerDrawingLibraryAssets/3A/1/M12148.pdf; Product Page URL: http://ecatalog.hubbell-wiring.com/press/pdfs/WLFHM003.pdf; Product url: http://ecatalog.hubbell-wiring.com/ProductInformation/ViewCatalog.aspx?Dest=hubbell-wiring.com/press/catalog/e.pdf; Produttore: Hubbell Wiring Device-Kellems; Titolo OmniClass: Lighting Controls; URL: http://www.hubbell-wiring.com/
Type - Elettrico - Number of Poles: 1; Power Factor: 1; Apparent Load: 0 W; Voltage: 3 V
Type - Generale - Edition number: 1; Nominal height: 0 m; Nominal width: 0 m; Brand url: http://www.hubbell-wiring.com/; Date of publishing: 9/28/2015; Manufacturer name: Hubbell Wiring Device-Kellems; Product family: Lighting Controls; Product group: Ceiling Sensor; Product SKU: hubbell-wlp450c; QR code: http://bimobject.com/hubbellwiring/product/hubbell-wlp450c; Region North America: US; Weight Net (Kg): 0
Type - Ingegneria elettrica - Load Classification: Lighting
Type - Materiali e finiture - Device Material: Plastic - Hubbell - White; Glass: Plastic - Hubbell - Translucent White
Type - Vincoli - Prospetto di default: 1.2192 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: WLP450C
Type - Pset_EnvironmentalImpactIndicators - Reference: WLP450C
Type - Pset_ManufacturerTypeInformation - Manufacturer: Hubbell Wiring Device-Kellems
Material: Plastic - Hubbell - White, Plastic - Hubbell - Translucent White
Altro - Famiglia: Ceiling_Sensor-Wireless_PIR-Hubbell_Wiring-WLP450C: WLP450C; Famiglia e tipo: Ceiling_Sensor-Wireless_PIR-Hubbell_Wiring-WLP450C: WLP450C; ID tipo: Ceiling_Sensor-Wireless_PIR-Hubbell_Wiring-WLP450C: WLP450C; Tipo: Ceiling_Sensor-Wireless_PIR-Hubbell_Wiring-WLP450C: WLP450C
Dimensioni - Area: 57.6078 m2; Volume: 0.000137285 m3
Elettrico - Circuiti - Dati elettrici: Power Supply 3 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Grafica - Field of View: no; PIR Major Motion: no; PIR Minor Motion: no
Name (Ceiling_Sensor-Wireless_PIR-Hubbell_Wiring-WLP450C:WLP450C:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9675334 | L00 - Piano Terra Piazza ELETTRICO | 580 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9685611 | L00 - Piano Terra Piazza ELETTRICO | 439 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9685692 | L00 - Piano Terra Piazza ELETTRICO | 441 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9685806 | L00 - Piano Terra Piazza ELETTRICO | 444 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9685830 | L00 - Piano Terra Piazza ELETTRICO | 445 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9686146 | L00 - Piano Terra Piazza ELETTRICO | 446 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9686167 | L00 - Piano Terra Piazza ELETTRICO | 447 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9686282 | L00 - Piano Terra Piazza ELETTRICO | 449 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9687626 | L00 - Piano Terra Piazza ELETTRICO | 458 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9687641 | L00 - Piano Terra Piazza ELETTRICO | 459 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9687692 | L00 - Piano Terra Piazza ELETTRICO | 461 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9687713 | L00 - Piano Terra Piazza ELETTRICO | 462 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9687842 | L00 - Piano Terra Piazza ELETTRICO | 464 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688010 | L00 - Piano Terra Piazza ELETTRICO | 466 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688022 | L00 - Piano Terra Piazza ELETTRICO | 467 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688159 | L00 - Piano Terra Piazza ELETTRICO | 468 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688251 | L00 - Piano Terra Piazza ELETTRICO | 470 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688467 | L00 - Piano Terra Piazza ELETTRICO | 474 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688703 | L00 - Piano Terra Piazza ELETTRICO | 475 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688715 | L00 - Piano Terra Piazza ELETTRICO | 476 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9688863 | L00 - Piano Terra Piazza ELETTRICO | 479 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9689217 | L00 - Piano Terra Piazza ELETTRICO | 481 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9689397 | L00 - Piano Terra Piazza ELETTRICO | 484 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9689611 | L00 - Piano Terra Piazza ELETTRICO | 485 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9689626 | L00 - Piano Terra Piazza ELETTRICO | 486 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9689681 | L00 - Piano Terra Piazza ELETTRICO | 488 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9690031 | L02 - Piano Secondo ELETTRICO | 490 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
10344436 | B01 - Piano Interrato ELETTRICO | 492 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
10344440 | B01 - Piano Interrato ELETTRICO | 494 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
10344451 | B01 - Piano Interrato ELETTRICO | 500 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
10344452 | B01 - Piano Interrato ELETTRICO | 501 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
10344454 | L00 - Piano Terra Piazza ELETTRICO | 502 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 5.4
10344457 | L00 - Piano Terra Piazza ELETTRICO | 504 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
10344472 | L00 - Piano Terra Piazza ELETTRICO | 512 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
10344474 | L00 - Piano Terra Piazza ELETTRICO | 514 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
10344475 | L00 - Piano Terra Piazza ELETTRICO | 515 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
10344485 | L00 - Piano Terra Piazza ELETTRICO | 521 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
10344486 | L02 - Piano Secondo ELETTRICO | 522 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
10344487 | L02 - Piano Secondo ELETTRICO | 523 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3
10344490 | L02 - Piano Secondo ELETTRICO | 526 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3

# IfcBuildingElementProxy: Centrale Emergenza:EEQ_I_CentraleEmergenza, Centrale Emergenza:EEQ_I_CentraleEmergenza:10665047
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Metallic Paint - Bose - Gray
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Centrale Emergenza
Type - Dati identità - Commenti sul tipo: ILL SIC; Nome del tipo: EEQ_I_CentraleEmergenza
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_I_CentraleEmergenza
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_I_CentraleEmergenza
Material: Metallic Paint - Bose - Gray, Plastic - Bose - Gray, Plastic - Bose - Grille, Presa cuffie lettore cd, Pulsanti lettore cd, Vetro display lettore cd, Dysplay lettore cd, Switch, Default, Manopole mixer bianco, Manopole mixer, Spie rosse mixer, Spie verdi mixer, Interruttore nero, Interruttori, Spia pannello alimentazione generale, Maniglia, Metallo, Vetro, Rack
Altro - Famiglia: Centrale Emergenza: EEQ_I_CentraleEmergenza; Famiglia e tipo: Centrale Emergenza: EEQ_I_CentraleEmergenza; ID tipo: Centrale Emergenza: EEQ_I_CentraleEmergenza; Tipo: Centrale Emergenza: EEQ_I_CentraleEmergenza
Dati identità - Contrassegno: 662
Dimensioni - Volume: 0.317613 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Offset da host: 0 m; Quota altimetrica da livello: 0 m; Host: Livello : L00 - Piano Terra Piazza ELETTRICO
Visibilità - Coppia amplificatori 1: yes; Coppia amplificatori 2: yes; Coppia amplificatori 3: yes; Coppia amplificatori 4: yes

# IfcBuildingElementProxy: Centrale TVCC:DSE_I_CentraleAntincendio, Centrale TVCC:DSE_I_CentraleAntincendio:10433585
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Serratura centrale
Type - Altro - Categoria: Dispositivi di sicurezza; Nome famiglia: Centrale TVCC
Type - Dati identità - Commenti sul tipo: Antincendio; Nome del tipo: DSE_I_CentraleAntincendio
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DSE_I_CentraleAntincendio
Type - Pset_EnvironmentalImpactIndicators - Reference: DSE_I_CentraleAntincendio
Material: Serratura centrale, Scatola centrale, Placchetta centrale
Altro - Famiglia: Centrale TVCC: DSE_I_CentraleAntincendio; Famiglia e tipo: Centrale TVCC: DSE_I_CentraleAntincendio; ID tipo: Centrale TVCC: DSE_I_CentraleAntincendio; Tipo: Centrale TVCC: DSE_I_CentraleAntincendio
Dati identità - Contrassegno: 545
Dimensioni - Area: 0.139562 m2; Volume: 0.00603036 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 1.24888 m

# IfcBuildingElementProxy: Centrale antintrusione:DSE_I_CentraleAntintrusione, Centrale antintrusione:DSE_I_CentraleAntintrusione:10433584
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Serratura centrale antintrusione
Type - Altro - Categoria: Dispositivi di sicurezza; Nome famiglia: Centrale antintrusione
Type - Dati identità - Commenti sul tipo: SAI; Nome del tipo: DSE_I_CentraleAntintrusione
Type - Vincoli - Prospetto di default: 1.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DSE_I_CentraleAntintrusione
Type - Pset_EnvironmentalImpactIndicators - Reference: DSE_I_CentraleAntintrusione
Material: Serratura centrale antintrusione, Scatola centrale antintrusione, Tasti centrale antintrusione, Placchetta centrale antintrusione
Altro - Famiglia: Centrale antintrusione: DSE_I_CentraleAntintrusione; Famiglia e tipo: Centrale antintrusione: DSE_I_CentraleAntintrusione; ID tipo: Centrale antintrusione: DSE_I_CentraleAntintrusione; Tipo: Centrale antintrusione: DSE_I_CentraleAntintrusione
Dati identità - Contrassegno: 544
Dimensioni - Area: 0.170558 m2; Volume: 0.00989864 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 1.22038 m

# IfcBuildingElementProxy: Centrale audio:EEQ_I_CentraleAudio, Centrale audio:EEQ_I_CentraleAudio:10433583
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Metallic Paint - Bose - Gray
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Centrale audio
Type - Dati identità - Nome del tipo: EEQ_I_CentraleAudio
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_I_CentraleAudio
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_I_CentraleAudio
Material: Metallic Paint - Bose - Gray, Plastic - Bose - Gray, Plastic - Bose - Grille, Presa cuffie lettore cd, Pulsanti lettore cd, Vetro display lettore cd, Dysplay lettore cd, Switch, Default, Manopole mixer bianco, Manopole mixer, Spie rosse mixer, Spie verdi mixer, Interruttore nero, Interruttori, Spia pannello alimentazione generale, Maniglia, Metallo, Vetro, Rack
Altro - Famiglia: Centrale audio: EEQ_I_CentraleAudio; Famiglia e tipo: Centrale audio: EEQ_I_CentraleAudio; ID tipo: Centrale audio: EEQ_I_CentraleAudio; Tipo: Centrale audio: EEQ_I_CentraleAudio
Dati identità - Contrassegno: 666
Dimensioni - Volume: 0.317613 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Offset da host: 0 m; Quota altimetrica da livello: 0 m; Host: Livello : L00 - Piano Terra Piazza ELETTRICO
Visibilità - Coppia amplificatori 1: yes; Coppia amplificatori 2: yes; Coppia amplificatori 3: yes; Coppia amplificatori 4: yes

# IfcBuildingElementProxy: Centrale fumi:EEQ_I_CentraleRivelazioneFumi (2)
Type - Material: GUAINA, VETRO1, Sportello centralino, GRIGIO RAL 7035, Acrylic Ivory
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Centrale fumi
Type - Dati identità - Commenti sul tipo: Rivelazione fumi; Nome del tipo: EEQ_I_CentraleRivelazioneFumi; Numero OmniClass: 23.80.30.11.17; Titolo OmniClass: Distribution Boards and Control Panels
Type - Materiali e finiture - Guaina: GUAINA; Oblò: VETRO1; Quadro: GRIGIO RAL 7035; Sportello: Sportello centralino
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_I_CentraleRivelazioneFumi
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_I_CentraleRivelazioneFumi
Material: Acrylic Ivory, Plastic, Render Material 82-165-124, Default, Render Material 102-102-102
Altro - Famiglia: Centrale fumi: EEQ_I_CentraleRivelazioneFumi; Famiglia e tipo: Centrale fumi: EEQ_I_CentraleRivelazioneFumi; ID tipo: Centrale fumi: EEQ_I_CentraleRivelazioneFumi; Tipo: Centrale fumi: EEQ_I_CentraleRivelazioneFumi
Dimensioni - Area: 0.70329 m2; Volume: 0.0320632 m3
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Prospetto di default: 0 m; Offset da host: 0 m; Quota altimetrica da livello: 0.948885 m
Name (Centrale fumi:EEQ_I_CentraleRivelazioneFumi:...) | In | Contrassegno | Livello = Livello abaco | Host
10433561 | L00 - Piano Terra Piazza ELETTRICO | 659 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10666025 | B01 - Piano Interrato ELETTRICO | 665 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Comandi illuminazione:DLG_I_Pulsante Singolo (19)
Type - Material: Frutto
Type - Altro - Categoria: Dispositivi di illuminazione; Nome famiglia: Comandi illuminazione; Tipologia presa: 01 - Comando singolo
Type - Dati identità - Commenti sul tipo: Comandi; Label: GFCI; Nome del tipo: DLG_I_Pulsante Singolo; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 120 V
Type - Grafica - Simbolo: 04
Type - Vincoli - Prospetto di default: 1.1 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DLG_I_Pulsante Singolo
Type - Pset_EnvironmentalImpactIndicators - Reference: DLG_I_Pulsante Singolo
Material: Frutto, Placca
Altro - Famiglia: Comandi illuminazione: DLG_I_Pulsante Singolo; Famiglia e tipo: Comandi illuminazione: DLG_I_Pulsante Singolo; ID tipo: Comandi illuminazione: DLG_I_Pulsante Singolo; Tipo: Comandi illuminazione: DLG_I_Pulsante Singolo
Dimensioni - Area: 0.0198502 m2; Distanza_simbolo: 0.5 m; Volume: 0.000133404 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Quota altimetrica da livello: 1.1 m
Name (Comandi illuminazione:DLG_I_Pulsante Singolo:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Host
9478139 | L00 - Piano Terra Piazza ELETTRICO | 702 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9478253 | L00 - Piano Terra Piazza ELETTRICO | 703 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9479429 | L00 - Piano Terra Piazza ELETTRICO | 729 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9479443 | L00 - Piano Terra Piazza ELETTRICO | 730 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9482265 | B01 - Piano Interrato ELETTRICO | 828 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9482295 | B01 - Piano Interrato ELETTRICO | 829 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9482457 | B01 - Piano Interrato ELETTRICO | 830 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9482582 | B01 - Piano Interrato ELETTRICO | 831 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9482776 | B01 - Piano Interrato ELETTRICO | 832 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9483049 | B01 - Piano Interrato ELETTRICO | 833 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9483572 | B01 - Piano Interrato ELETTRICO | 834 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9484151 | B01 - Piano Interrato ELETTRICO | 835 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9484192 | B01 - Piano Interrato ELETTRICO | 836 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9484389 | B01 - Piano Interrato ELETTRICO | 837 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9484609 | B01 - Piano Interrato ELETTRICO | 838 | Livello: B01 - Piano Interrato ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9485297 | B01 - Piano Interrato ELETTRICO | 839 | Livello: B01 - Piano Interrato ELETTRICO | 0.0976296 | <non associato>
9659171 | L02 - Piano Secondo ELETTRICO | 841 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
9659172 | L02 - Piano Secondo ELETTRICO | 842 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
9659174 | L03 - Piano Terzo ELETTRICO | 843 | Livello: L03 - Piano Terzo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Contatto magnetico porte allarmate:DSE_I_ContattoMagneticoPorteAllarmate (57)
Type - Material: Placca
Type - Altro - Categoria: Dispositivi di sicurezza; Nome famiglia: Contatto magnetico porte allarmate
Type - Dati identità - Commenti sul tipo: SAI; Label: GFCI; Nome del tipo: DSE_I_ContattoMagneticoPorteAllarmate; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Dimensioni - Frutto_Altezza: 0.046 m; Frutto_Larghezza: 0.068 m; Placca_Altezza: 0.086 m; Placca_Larghezza: 0.122 m
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Vincoli - Prospetto di default: 0.33 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: DSE_I_ContattoMagneticoPorteAllarmate
Type - Pset_EnvironmentalImpactIndicators - Reference: DSE_I_ContattoMagneticoPorteAllarmate
Material: Placca, Metallo
Altro - Famiglia: Contatto magnetico porte allarmate: DSE_I_ContattoMagneticoPorteAllarmate; Famiglia e tipo: Contatto magnetico porte allarmate: DSE_I_ContattoMagneticoPorteAllarmate; ID tipo: Contatto magnetico porte allarmate: DSE_I_ContattoMagneticoPorteAllarmate; Tipo: Contatto magnetico porte allarmate: DSE_I_ContattoMagneticoPorteAllarmate
Dimensioni - Area: 0.00244962 m2; Distanza simbolo: 0.5 m; Volume: 0.00000602754 m3
Elettrico - Load: 500 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
Name (Contatto magnetico porte allarmate:DSE_I_ContattoMagneticoPorteAllarmate:...) | In | Contrassegno | Livello = Livello abaco | Quota altimetrica da livello (m)
9612685 | L00 - Piano Terra Piazza ELETTRICO | 354 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.21205
9612699 | L00 - Piano Terra Piazza ELETTRICO | 355 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.22542
9613299 | L00 - Piano Terra Piazza ELETTRICO | 356 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.33838
9613358 | L00 - Piano Terra Piazza ELETTRICO | 357 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.33809
9613416 | L00 - Piano Terra Piazza ELETTRICO | 358 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.33935
9613473 | L00 - Piano Terra Piazza ELETTRICO | 359 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.34421
9613654 | L00 - Piano Terra Piazza ELETTRICO | 360 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.13529
9613709 | L00 - Piano Terra Piazza ELETTRICO | 361 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.13328
9613763 | L00 - Piano Terra Piazza ELETTRICO | 362 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.09025
9614066 | L00 - Piano Terra Piazza ELETTRICO | 363 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.23764
9614342 | L00 - Piano Terra Piazza ELETTRICO | 364 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.13461
9614573 | L00 - Piano Terra Piazza ELETTRICO | 365 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.23618
9614701 | L00 - Piano Terra Piazza ELETTRICO | 366 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.23996
9614887 | L00 - Piano Terra Piazza ELETTRICO | 367 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.23305
9615054 | L00 - Piano Terra Piazza ELETTRICO | 368 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.22037
9615232 | L00 - Piano Terra Piazza ELETTRICO | 369 | Livello: L00 - Piano Terra Piazza ELETTRICO | 2.23346
