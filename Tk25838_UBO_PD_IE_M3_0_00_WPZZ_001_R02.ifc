Properties of the parts of a building model (IFC4), part 21 of 23

# IfcLightFixture: Lighting_WallMounted_LineaLightGroup_Quara65_RI:92671M70 (60)
Name (Lighting_WallMounted_LineaLightGroup_Quara65_RI:92671M70:...) | Contrassegno | Host | Quota altimetrica da livello (m)
10710014 | 6355 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.208737
10710025 | 6356 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.355658
10710037 | 6357 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.49157
10710061 | 6358 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.64662
10710073 | 6359 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.768981
10710085 | 6360 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.903031
10710236 | 6361 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.05384
10710248 | 6362 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.18603
10710260 | 6363 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.32566
10710272 | 6364 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.46344
10710284 | 6365 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.60307
10710296 | 6366 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.7576
10710307 | 6367 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.88979
10710319 | 6368 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.02943
10710336 | 6369 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.17465
10710354 | 6370 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.31056
10710366 | 6371 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.44461
10710384 | 6372 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.58983
10710396 | 6373 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.72389
10710667 | 6374 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.0664093
10710668 | 6375 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.20726
10710669 | 6376 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.354181
10710671 | 6377 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.490093
10710673 | 6378 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.635315
10710675 | 6379 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.767504
10710677 | 6380 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.901554
10710679 | 6381 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.05236
10710681 | 6382 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.18455
10710683 | 6383 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.32419
10710685 | 6384 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.46196
10710687 | 6385 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.6016
10710689 | 6386 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.75613
10710690 | 6387 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.88832
10710692 | 6388 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.02795
10710693 | 6389 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.17317
10710695 | 6390 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.30909
10710697 | 6391 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.44314
10710699 | 6392 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.58836
10710701 | 6393 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.7246
10710795 | 6394 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.0630357
10710796 | 6395 | <non associato> | -0.203886
10710797 | 6396 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.350807
10710798 | 6397 | <non associato> | -0.48672
10710799 | 6398 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.631941
10710800 | 6399 | <non associato> | -0.76413
10710801 | 6400 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -0.898181
10710802 | 6401 | <non associato> | -1.04899
10710803 | 6402 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.18118
10710804 | 6403 | <non associato> | -1.32081
10710805 | 6404 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.45859
10710806 | 6405 | <non associato> | -1.59822
10710807 | 6406 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -1.75275
10710808 | 6407 | <non associato> | -1.88494
10710809 | 6408 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.02458
10710810 | 6409 | <non associato> | -2.1698
10710811 | 6410 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.30571
10710812 | 6411 | <non associato> | -2.43976
10710813 | 6412 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.58498
10710814 | 6413 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | -2.72123

# IfcLightFixture: OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46025 (221)
Type - Material: Verre, polycarbonate thermodurcissable blanc
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA (cerchio)
Type - Dati identità - Classe de Protection: IP65; Commenti sul tipo: 25; Descrizione: Spot muni de deux LED de grande puissance et de lentilles optiques créant un faisceau de lumière circulaire, idéal pour réaliser un éclairage dans des halles de grandes hauteurs. Spot apparent de faible hauteur, constitué d'un boîtier en polycarbonate étanche (IP65) permettant son installation dans des lieux humides ou poussiéreux, il est de plus pourvu d'une membrane de compensation de pression. Alimenté par une armoire d’énergie APG 230 VAC cet appareil est prévu pour être utilisé comme luminaire secours.; Indice de résist. aux chocs: IK04; Modello: SPP/230C; Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46025; Numero OmniClass: 23.80.70.00; Produttore: Aprotec; Titolo OmniClass: Lighting; URL: www.aprotec.ch
Type - Elettrico - Carichi - Alimentation: 230 V; Carico apparente: 10 W; Puissance LED: 3 W
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: 90 deg; Emetti da lunghezza linea: 0.6096 m; Definizione sorgente d'illuminazione (famiglia): Linea+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; File diagramma fotometrico: aprotec_spp_230c_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 480 lm; Illuminanza: 4.11151 lx; Intensità luminosa: 38.1972 cd; Temperatura colore iniziale: 4000 K; Watt: 3.23141 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46025
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46025
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aprotec
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46025; Famiglia e tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46025; ID tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46025; Tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46025
Dati identità - Déclaration de conformité: https://bim-mo.ch/wp-content/uploads/2019/03/SPP.pdf; Fiche technique: http://www.aprotec.ch/data/products/pdf/aprotec-spp-230c.pdf; Modélisation: www.bim-mo.ch; Notice de Montage: https://bim-mo.ch/wp-content/uploads/2019/03/SPP-1.pdf
Dimensioni - Volume: 0.00102695 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-10 W
Fasi - Fase di creazione: Nuova costruzione
Name (OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46025:...) | In | Contrassegno | Livello = Livello abaco | Offset da host (m) | Piano di lavoro | Quota altimetrica da livello (m)
9496836 | L00 - Piano Terra Piazza ELETTRICO | 5496 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499560 | L00 - Piano Terra Piazza ELETTRICO | 5498 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499572 | L00 - Piano Terra Piazza ELETTRICO | 5499 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499582 | L00 - Piano Terra Piazza ELETTRICO | 5500 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499590 | L00 - Piano Terra Piazza ELETTRICO | 5501 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499600 | L00 - Piano Terra Piazza ELETTRICO | 5502 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499612 | L00 - Piano Terra Piazza ELETTRICO | 5503 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499620 | L00 - Piano Terra Piazza ELETTRICO | 5504 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499630 | L00 - Piano Terra Piazza ELETTRICO | 5505 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499640 | L00 - Piano Terra Piazza ELETTRICO | 5506 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499650 | L00 - Piano Terra Piazza ELETTRICO | 5507 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499662 | L00 - Piano Terra Piazza ELETTRICO | 5508 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499670 | L00 - Piano Terra Piazza ELETTRICO | 5509 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499680 | L00 - Piano Terra Piazza ELETTRICO | 5510 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499688 | L00 - Piano Terra Piazza ELETTRICO | 5511 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499696 | L00 - Piano Terra Piazza ELETTRICO | 5512 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499708 | L00 - Piano Terra Piazza ELETTRICO | 5513 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499720 | L00 - Piano Terra Piazza ELETTRICO | 5514 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499728 | L00 - Piano Terra Piazza ELETTRICO | 5515 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499736 | L00 - Piano Terra Piazza ELETTRICO | 5516 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499746 | L00 - Piano Terra Piazza ELETTRICO | 5517 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9499960 | L00 - Piano Terra Piazza ELETTRICO | 5525 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500006 | L00 - Piano Terra Piazza ELETTRICO | 5528 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9500054 | L00 - Piano Terra Piazza ELETTRICO | 5529 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9500087 | L00 - Piano Terra Piazza ELETTRICO | 5530 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500132 | L00 - Piano Terra Piazza ELETTRICO | 5531 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500142 | L00 - Piano Terra Piazza ELETTRICO | 5532 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500150 | L00 - Piano Terra Piazza ELETTRICO | 5533 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500158 | L00 - Piano Terra Piazza ELETTRICO | 5534 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500168 | L00 - Piano Terra Piazza ELETTRICO | 5535 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500176 | L00 - Piano Terra Piazza ELETTRICO | 5536 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500186 | L00 - Piano Terra Piazza ELETTRICO | 5537 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0236648 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.02366
9500196 | L00 - Piano Terra Piazza ELETTRICO | 5538 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500206 | L00 - Piano Terra Piazza ELETTRICO | 5539 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500325 | L00 - Piano Terra Piazza ELETTRICO | 5540 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500335 | L00 - Piano Terra Piazza ELETTRICO | 5541 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500343 | L00 - Piano Terra Piazza ELETTRICO | 5542 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500353 | L00 - Piano Terra Piazza ELETTRICO | 5543 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500361 | L00 - Piano Terra Piazza ELETTRICO | 5544 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500369 | L00 - Piano Terra Piazza ELETTRICO | 5545 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500381 | L00 - Piano Terra Piazza ELETTRICO | 5546 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500389 | L00 - Piano Terra Piazza ELETTRICO | 5547 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500397 | L00 - Piano Terra Piazza ELETTRICO | 5548 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500433 | L00 - Piano Terra Piazza ELETTRICO | 5552 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500445 | L00 - Piano Terra Piazza ELETTRICO | 5553 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500479 | L00 - Piano Terra Piazza ELETTRICO | 5554 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500487 | L00 - Piano Terra Piazza ELETTRICO | 5555 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500495 | L00 - Piano Terra Piazza ELETTRICO | 5556 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500505 | L00 - Piano Terra Piazza ELETTRICO | 5557 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500515 | L00 - Piano Terra Piazza ELETTRICO | 5558 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500525 | L00 - Piano Terra Piazza ELETTRICO | 5559 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500535 | L00 - Piano Terra Piazza ELETTRICO | 5560 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500543 | L00 - Piano Terra Piazza ELETTRICO | 5561 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500551 | L00 - Piano Terra Piazza ELETTRICO | 5562 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500622 | L00 - Piano Terra Piazza ELETTRICO | 5563 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500634 | L00 - Piano Terra Piazza ELETTRICO | 5564 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500690 | L00 - Piano Terra Piazza ELETTRICO | 5565 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500706 | L00 - Piano Terra Piazza ELETTRICO | 5566 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500716 | L00 - Piano Terra Piazza ELETTRICO | 5567 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | <non associato> | 4
9500908 | L00 - Piano Terra Piazza ELETTRICO | 5568 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | <non associato> | 4
9500940 | L00 - Piano Terra Piazza ELETTRICO | 5569 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500950 | L00 - Piano Terra Piazza ELETTRICO | 5570 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500962 | L00 - Piano Terra Piazza ELETTRICO | 5571 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500970 | L00 - Piano Terra Piazza ELETTRICO | 5572 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500978 | L00 - Piano Terra Piazza ELETTRICO | 5573 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500988 | L00 - Piano Terra Piazza ELETTRICO | 5574 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9500998 | L00 - Piano Terra Piazza ELETTRICO | 5575 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501008 | L00 - Piano Terra Piazza ELETTRICO | 5576 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501016 | L00 - Piano Terra Piazza ELETTRICO | 5577 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501024 | L00 - Piano Terra Piazza ELETTRICO | 5578 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501034 | L00 - Piano Terra Piazza ELETTRICO | 5579 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501044 | L00 - Piano Terra Piazza ELETTRICO | 5580 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501052 | L00 - Piano Terra Piazza ELETTRICO | 5581 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501060 | L00 - Piano Terra Piazza ELETTRICO | 5582 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501068 | L00 - Piano Terra Piazza ELETTRICO | 5583 | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.041882 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.95812
9501076 | L00 - Piano Terra Piazza ELETTRICO | 5584 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501084 | L00 - Piano Terra Piazza ELETTRICO | 5585 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501098 | L00 - Piano Terra Piazza ELETTRICO | 5586 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501112 | L00 - Piano Terra Piazza ELETTRICO | 5587 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501122 | L00 - Piano Terra Piazza ELETTRICO | 5588 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501130 | L00 - Piano Terra Piazza ELETTRICO | 5589 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501140 | L00 - Piano Terra Piazza ELETTRICO | 5590 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501150 | L00 - Piano Terra Piazza ELETTRICO | 5591 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501158 | L00 - Piano Terra Piazza ELETTRICO | 5592 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501168 | L00 - Piano Terra Piazza ELETTRICO | 5593 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501178 | L00 - Piano Terra Piazza ELETTRICO | 5594 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501190 | L00 - Piano Terra Piazza ELETTRICO | 5595 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501198 | L00 - Piano Terra Piazza ELETTRICO | 5596 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501210 | L00 - Piano Terra Piazza ELETTRICO | 5597 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501220 | L00 - Piano Terra Piazza ELETTRICO | 5598 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501336 | L00 - Piano Terra Piazza ELETTRICO | 5599 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501372 | L00 - Piano Terra Piazza ELETTRICO | 5600 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501381 | L00 - Piano Terra Piazza ELETTRICO | 5601 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501391 | L00 - Piano Terra Piazza ELETTRICO | 5602 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501417 | L00 - Piano Terra Piazza ELETTRICO | 5603 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501428 | L00 - Piano Terra Piazza ELETTRICO | 5604 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501492 | L00 - Piano Terra Piazza ELETTRICO | 5605 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501500 | L00 - Piano Terra Piazza ELETTRICO | 5606 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501508 | L00 - Piano Terra Piazza ELETTRICO | 5607 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501516 | L00 - Piano Terra Piazza ELETTRICO | 5608 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501524 | L00 - Piano Terra Piazza ELETTRICO | 5609 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501534 | L00 - Piano Terra Piazza ELETTRICO | 5610 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501544 | L00 - Piano Terra Piazza ELETTRICO | 5611 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501569 | L00 - Piano Terra Piazza ELETTRICO | 5612 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501598 | L00 - Piano Terra Piazza ELETTRICO | 5613 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501607 | L00 - Piano Terra Piazza ELETTRICO | 5614 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501616 | L00 - Piano Terra Piazza ELETTRICO | 5615 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501629 | L00 - Piano Terra Piazza ELETTRICO | 5616 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501677 | L00 - Piano Terra Piazza ELETTRICO | 5617 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501685 | L00 - Piano Terra Piazza ELETTRICO | 5618 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9501715 | L00 - Piano Terra Piazza ELETTRICO | 5619 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501751 | L00 - Piano Terra Piazza ELETTRICO | 5620 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501812 | L00 - Piano Terra Piazza ELETTRICO | 5621 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501915 | L00 - Piano Terra Piazza ELETTRICO | 5622 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9501924 | L00 - Piano Terra Piazza ELETTRICO | 5623 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502100 | L00 - Piano Terra Piazza ELETTRICO | 5628 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502111 | L00 - Piano Terra Piazza ELETTRICO | 5629 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502121 | L00 - Piano Terra Piazza ELETTRICO | 5630 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502196 | L00 - Piano Terra Piazza ELETTRICO | 5631 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502204 | L00 - Piano Terra Piazza ELETTRICO | 5632 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502248 | L00 - Piano Terra Piazza ELETTRICO | 5633 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502258 | L00 - Piano Terra Piazza ELETTRICO | 5634 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502398 | L00 - Piano Terra Piazza ELETTRICO | 5637 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502406 | L00 - Piano Terra Piazza ELETTRICO | 5638 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502420 | L00 - Piano Terra Piazza ELETTRICO | 5639 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502428 | L00 - Piano Terra Piazza ELETTRICO | 5640 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502436 | L00 - Piano Terra Piazza ELETTRICO | 5641 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502444 | L00 - Piano Terra Piazza ELETTRICO | 5642 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502454 | L00 - Piano Terra Piazza ELETTRICO | 5643 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502464 | L00 - Piano Terra Piazza ELETTRICO | 5644 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502472 | L00 - Piano Terra Piazza ELETTRICO | 5645 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502484 | L00 - Piano Terra Piazza ELETTRICO | 5646 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502492 | L00 - Piano Terra Piazza ELETTRICO | 5647 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502500 | L00 - Piano Terra Piazza ELETTRICO | 5648 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502513 | L00 - Piano Terra Piazza ELETTRICO | 5649 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502523 | L00 - Piano Terra Piazza ELETTRICO | 5650 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9502531 | L00 - Piano Terra Piazza ELETTRICO | 5651 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503118 | L00 - Piano Terra Piazza ELETTRICO | 5664 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503492 | L00 - Piano Terra Piazza ELETTRICO | 5671 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503547 | L00 - Piano Terra Piazza ELETTRICO | 5672 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503555 | L00 - Piano Terra Piazza ELETTRICO | 5673 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503569 | L00 - Piano Terra Piazza ELETTRICO | 5674 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503577 | L00 - Piano Terra Piazza ELETTRICO | 5675 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503587 | L00 - Piano Terra Piazza ELETTRICO | 5676 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503597 | L00 - Piano Terra Piazza ELETTRICO | 5677 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503609 | L00 - Piano Terra Piazza ELETTRICO | 5678 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503619 | L00 - Piano Terra Piazza ELETTRICO | 5679 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503629 | L00 - Piano Terra Piazza ELETTRICO | 5680 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503637 | L00 - Piano Terra Piazza ELETTRICO | 5681 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503645 | L00 - Piano Terra Piazza ELETTRICO | 5682 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503655 | L00 - Piano Terra Piazza ELETTRICO | 5683 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503663 | L00 - Piano Terra Piazza ELETTRICO | 5684 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503675 | L00 - Piano Terra Piazza ELETTRICO | 5685 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503683 | L00 - Piano Terra Piazza ELETTRICO | 5686 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503691 | L00 - Piano Terra Piazza ELETTRICO | 5687 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503701 | L00 - Piano Terra Piazza ELETTRICO | 5688 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503709 | L00 - Piano Terra Piazza ELETTRICO | 5689 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503717 | L00 - Piano Terra Piazza ELETTRICO | 5690 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503761 | L00 - Piano Terra Piazza ELETTRICO | 5691 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503769 | L00 - Piano Terra Piazza ELETTRICO | 5692 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503781 | L00 - Piano Terra Piazza ELETTRICO | 5693 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503789 | L00 - Piano Terra Piazza ELETTRICO | 5694 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9503797 | L00 - Piano Terra Piazza ELETTRICO | 5695 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9504597 | L00 - Piano Terra Piazza ELETTRICO | 5728 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504645 | L00 - Piano Terra Piazza ELETTRICO | 5729 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504657 | L00 - Piano Terra Piazza ELETTRICO | 5730 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504667 | L00 - Piano Terra Piazza ELETTRICO | 5731 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504675 | L00 - Piano Terra Piazza ELETTRICO | 5732 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504683 | L00 - Piano Terra Piazza ELETTRICO | 5733 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504691 | L00 - Piano Terra Piazza ELETTRICO | 5734 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504699 | L00 - Piano Terra Piazza ELETTRICO | 5735 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504709 | L00 - Piano Terra Piazza ELETTRICO | 5736 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504717 | L00 - Piano Terra Piazza ELETTRICO | 5737 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504727 | L00 - Piano Terra Piazza ELETTRICO | 5738 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504737 | L00 - Piano Terra Piazza ELETTRICO | 5739 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.2
9504803 | L00 - Piano Terra Piazza ELETTRICO | 5740 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504832 | L00 - Piano Terra Piazza ELETTRICO | 5741 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504840 | L00 - Piano Terra Piazza ELETTRICO | 5742 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504850 | L00 - Piano Terra Piazza ELETTRICO | 5743 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504861 | L00 - Piano Terra Piazza ELETTRICO | 5744 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504869 | L00 - Piano Terra Piazza ELETTRICO | 5745 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504877 | L00 - Piano Terra Piazza ELETTRICO | 5746 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504885 | L00 - Piano Terra Piazza ELETTRICO | 5747 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504893 | L00 - Piano Terra Piazza ELETTRICO | 5748 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504901 | L00 - Piano Terra Piazza ELETTRICO | 5749 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504911 | L00 - Piano Terra Piazza ELETTRICO | 5750 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504919 | L00 - Piano Terra Piazza ELETTRICO | 5751 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9504959 | L00 - Piano Terra Piazza ELETTRICO | 5752 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9504991 | L00 - Piano Terra Piazza ELETTRICO | 5753 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9504999 | L00 - Piano Terra Piazza ELETTRICO | 5754 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505053 | L00 - Piano Terra Piazza ELETTRICO | 5755 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505061 | L00 - Piano Terra Piazza ELETTRICO | 5756 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505069 | L00 - Piano Terra Piazza ELETTRICO | 5757 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505079 | L00 - Piano Terra Piazza ELETTRICO | 5758 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505087 | L00 - Piano Terra Piazza ELETTRICO | 5759 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505095 | L00 - Piano Terra Piazza ELETTRICO | 5760 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505103 | L00 - Piano Terra Piazza ELETTRICO | 5761 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9505143 | L00 - Piano Terra Piazza ELETTRICO | 5762 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505153 | L00 - Piano Terra Piazza ELETTRICO | 5763 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505163 | L00 - Piano Terra Piazza ELETTRICO | 5764 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505175 | L00 - Piano Terra Piazza ELETTRICO | 5765 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505185 | L00 - Piano Terra Piazza ELETTRICO | 5766 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505193 | L00 - Piano Terra Piazza ELETTRICO | 5767 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505201 | L00 - Piano Terra Piazza ELETTRICO | 5768 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505211 | L00 - Piano Terra Piazza ELETTRICO | 5769 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505219 | L00 - Piano Terra Piazza ELETTRICO | 5770 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505229 | L00 - Piano Terra Piazza ELETTRICO | 5771 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505239 | L00 - Piano Terra Piazza ELETTRICO | 5772 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505249 | L00 - Piano Terra Piazza ELETTRICO | 5773 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3.5
9505300 | L00 - Piano Terra Piazza ELETTRICO | 5774 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9505314 | L00 - Piano Terra Piazza ELETTRICO | 5775 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9505324 | L00 - Piano Terra Piazza ELETTRICO | 5776 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9505332 | L00 - Piano Terra Piazza ELETTRICO | 5777 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9505342 | L00 - Piano Terra Piazza ELETTRICO | 5778 | Livello: L01 - Piano Primo ELETTRICO | 0 | <non associato> | 3
9508985 | L02 - Piano Secondo ELETTRICO | 5952 | Livello: L02 - Piano Secondo ELETTRICO | 0 | <non associato> | 3
9509017 | L02 - Piano Secondo ELETTRICO | 5953 | Livello: L02 - Piano Secondo ELETTRICO | 0 | <non associato> | 3
9519535 | L00 - Piano Terra Piazza ELETTRICO | 6014 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9519614 | L00 - Piano Terra Piazza ELETTRICO | 6015 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9519630 | L00 - Piano Terra Piazza ELETTRICO | 6016 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9535362 | L00 - Piano Terra Piazza ELETTRICO | 6070 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9540034 | L00 - Piano Terra Piazza ELETTRICO | 6071 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5

# IfcLightFixture: OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46026 (103)
Type - Material: Verre, polycarbonate thermodurcissable blanc
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: OVA (cerchio)
Type - Dati identità - Classe de Protection: IP65; Commenti sul tipo: 26; Descrizione: Spot muni de deux LED de grande puissance et de lentilles optiques créant un faisceau de lumière circulaire, idéal pour réaliser un éclairage dans des halles de grandes hauteurs. Spot apparent de faible hauteur, constitué d'un boîtier en polycarbonate étanche (IP65) permettant son installation dans des lieux humides ou poussiéreux, il est de plus pourvu d'une membrane de compensation de pression. Alimenté par une armoire d’énergie APG 230 VAC cet appareil est prévu pour être utilisé comme luminaire secours.; Indice de résist. aux chocs: IK04; Modello: SPP/230C; Nome del tipo: LFX_I_IguzziniMod._TipoOvaMod.46026; Numero OmniClass: 23.80.70.00; Produttore: Aprotec; Titolo OmniClass: Lighting; URL: www.aprotec.ch
Type - Elettrico - Carichi - Alimentation: 230 V; Carico apparente: 10 W; Puissance LED: 3 W
Type - Fotometrica - Colore iniziale: 0; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; Intensità iniziale: 0; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Angolo inclinazione: 90 deg; Emetti da lunghezza linea: 0.6096 m; Definizione sorgente d'illuminazione (famiglia): Linea+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; File diagramma fotometrico: aprotec_spp_230c_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 480 lm; Illuminanza: 4.11151 lx; Intensità luminosa: 38.1972 cd; Temperatura colore iniziale: 4000 K; Watt: 3.23141 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod._TipoOvaMod.46026
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod._TipoOvaMod.46026
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aprotec
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46026; Famiglia e tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46026; ID tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46026; Tipo: OVA (cerchio): LFX_I_IguzziniMod._TipoOvaMod.46026
Dati identità - Déclaration de conformité: https://bim-mo.ch/wp-content/uploads/2019/03/SPP.pdf; Fiche technique: http://www.aprotec.ch/data/products/pdf/aprotec-spp-230c.pdf; Modélisation: www.bim-mo.ch; Notice de Montage: https://bim-mo.ch/wp-content/uploads/2019/03/SPP-1.pdf
Dimensioni - Volume: 0.00102695 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-10 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (OVA (cerchio):LFX_I_IguzziniMod._TipoOvaMod.46026:...) | In | Contrassegno | Livello = Livello abaco | Piano di lavoro | Quota altimetrica da livello (m)
9502315 | L00 - Piano Terra Piazza ELETTRICO | 5635 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9502363 | L00 - Piano Terra Piazza ELETTRICO | 5636 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9503890 | L00 - Piano Terra Piazza ELETTRICO | 5697 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9503925 | L00 - Piano Terra Piazza ELETTRICO | 5698 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9503969 | L00 - Piano Terra Piazza ELETTRICO | 5699 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9504020 | L00 - Piano Terra Piazza ELETTRICO | 5700 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9504055 | L00 - Piano Terra Piazza ELETTRICO | 5701 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9504063 | L00 - Piano Terra Piazza ELETTRICO | 5702 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9504149 | L00 - Piano Terra Piazza ELETTRICO | 5703 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504180 | L00 - Piano Terra Piazza ELETTRICO | 5704 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504188 | L00 - Piano Terra Piazza ELETTRICO | 5705 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504196 | L00 - Piano Terra Piazza ELETTRICO | 5706 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504204 | L00 - Piano Terra Piazza ELETTRICO | 5707 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504212 | L00 - Piano Terra Piazza ELETTRICO | 5708 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504220 | L00 - Piano Terra Piazza ELETTRICO | 5709 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504228 | L00 - Piano Terra Piazza ELETTRICO | 5710 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504238 | L00 - Piano Terra Piazza ELETTRICO | 5711 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504248 | L00 - Piano Terra Piazza ELETTRICO | 5712 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504256 | L00 - Piano Terra Piazza ELETTRICO | 5713 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504264 | L00 - Piano Terra Piazza ELETTRICO | 5714 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504272 | L00 - Piano Terra Piazza ELETTRICO | 5715 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504284 | L00 - Piano Terra Piazza ELETTRICO | 5716 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504325 | L00 - Piano Terra Piazza ELETTRICO | 5717 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504333 | L00 - Piano Terra Piazza ELETTRICO | 5718 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504341 | L00 - Piano Terra Piazza ELETTRICO | 5719 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504353 | L00 - Piano Terra Piazza ELETTRICO | 5720 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504363 | L00 - Piano Terra Piazza ELETTRICO | 5721 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504423 | L00 - Piano Terra Piazza ELETTRICO | 5722 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504472 | L00 - Piano Terra Piazza ELETTRICO | 5723 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504484 | L00 - Piano Terra Piazza ELETTRICO | 5724 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504492 | L00 - Piano Terra Piazza ELETTRICO | 5725 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504502 | L00 - Piano Terra Piazza ELETTRICO | 5726 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9504572 | L00 - Piano Terra Piazza ELETTRICO | 5727 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506507 | L00 - Piano Terra Piazza ELETTRICO | 5836 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506540 | L00 - Piano Terra Piazza ELETTRICO | 5837 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506580 | L00 - Piano Terra Piazza ELETTRICO | 5838 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506588 | L00 - Piano Terra Piazza ELETTRICO | 5839 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506596 | L00 - Piano Terra Piazza ELETTRICO | 5840 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506604 | L00 - Piano Terra Piazza ELETTRICO | 5841 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506612 | L00 - Piano Terra Piazza ELETTRICO | 5842 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506620 | L00 - Piano Terra Piazza ELETTRICO | 5843 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506630 | L00 - Piano Terra Piazza ELETTRICO | 5844 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506640 | L00 - Piano Terra Piazza ELETTRICO | 5845 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506651 | L00 - Piano Terra Piazza ELETTRICO | 5846 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506660 | L00 - Piano Terra Piazza ELETTRICO | 5847 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506733 | L00 - Piano Terra Piazza ELETTRICO | 5848 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9506741 | L00 - Piano Terra Piazza ELETTRICO | 5849 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9507935 | L02 - Piano Secondo ELETTRICO | 5896 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9507973 | L02 - Piano Secondo ELETTRICO | 5897 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9507983 | L02 - Piano Secondo ELETTRICO | 5898 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9508047 | L02 - Piano Secondo ELETTRICO | 5899 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9508057 | L02 - Piano Secondo ELETTRICO | 5900 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9508099 | L02 - Piano Secondo ELETTRICO | 5901 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9508137 | L02 - Piano Secondo ELETTRICO | 5902 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9508146 | L02 - Piano Secondo ELETTRICO | 5903 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9508154 | L02 - Piano Secondo ELETTRICO | 5904 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9508464 | L02 - Piano Secondo ELETTRICO | 5924 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662764 | L02 - Piano Secondo ELETTRICO | 6151 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662788 | L02 - Piano Secondo ELETTRICO | 6152 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662803 | L02 - Piano Secondo ELETTRICO | 6153 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662836 | L02 - Piano Secondo ELETTRICO | 6154 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662860 | L02 - Piano Secondo ELETTRICO | 6155 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662880 | L02 - Piano Secondo ELETTRICO | 6156 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662916 | L02 - Piano Secondo ELETTRICO | 6158 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662943 | L02 - Piano Secondo ELETTRICO | 6159 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662966 | L02 - Piano Secondo ELETTRICO | 6160 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9662981 | L02 - Piano Secondo ELETTRICO | 6161 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
9662996 | L02 - Piano Secondo ELETTRICO | 6162 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.7
