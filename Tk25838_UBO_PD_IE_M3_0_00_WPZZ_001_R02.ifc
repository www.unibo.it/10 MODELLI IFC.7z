Properties of the parts of a building model (IFC4), part 13 of 23

# IfcLightFixture: LFX_E_IguzziniMod.Bg19:LFX_E_IguzziniMod.Bg19 (53)
Type - Generale - OnlyDefault: yes; ModVariant: no; ApiVersion: 132383237; ConversionDate: 11/11/2021 4:20:53 PM; ConverterVersion: 2020.2.4.0; ProductGroupID: 3303; RlxChecksum: 83ffd873da33bf92d088c27c4eec54c8; RlxData: ZN3q8ryccAAPlln3QzzoAAAAAAAAjAAAAAAAAAOW/AnsAf7Yb7fCEQFjjkd4QJ1hhimdCgkalupR8n/1RkZvNrCxaNpnP5474di0/5GE6vp0yjnaSYpn3SESXuw4xxVOnkcw+/taP/U9F4xrALoGNLdWkk7Kwtj25rF9I9J4whaG0GjxzLVOP+5Yne7Rdiel/7JnTxChQfnvXiUqiX/Q3xeKjCwWNttyW35YgNH/Hc3h/VJfKKXrAXARK+DvLEB3cb3hwR/de6PaKUU84YhrHQBmxAH0bFQqKW0uA1OjiT9tCXvZjNi9WJ2fVZ64ahhVpwmsGD2RJtWkwZ4H3jLzQBhs9HlY8f3aRZclTjBgzvp/0pCx8h3g9ME3v6idSwvrHBD2/BGwIIrrEHXJizKaYIdCikfEbwkfDs3me6L7ZQc5UkhoygeeCA0HjxRKVdlvWa3MJzeHvY0kDtQOHv+fk8hOUbcz45JxCmOQkPTV3Ikrm2ByUlxqy2ZLKgPOWtjb/zNwdQhA5fslef9+sFGwFZnVIcA+s2MAaeyGoywQM3GPy3uq9+yfyJKF1BCvg+xby+OHRROqUxsd3rpMDlqZFVKlMP1y4nlN10s9biFOfd73g6mJxgQYZqt9o5n+qyLp/xXdyIJlTaxakHYtB7tJeml1AOkQNCMpmpesbMh/v26tLoE34d1NjSsHkVa6RogJN+kqUEtONNzkiWYr6MvNPNWgV4L5Ng3qRXWxsQfU0E9Om75VKHgQzlVLtoJLRfByFaJoZS7FwUmBXZXl9HF2hP3DlJksMxtRp8RK5SmoFmI94mCK3Jj4G2Q8rFhu7ybiVPNuHi0pK3yE1rCQrRMPTG/PNIq2T/V9TRdJXQU1oEpGDtg0BJKz4awsKKs9qQdUH2ZxLM6iFmd6WmIoIFws9vNoH6WCpn79Z22250SPS1uYCOLAfcESRf1aIUjW6tZXkJXMzkYtHbi5DHFEjwVSc/b2s6yj3LFEV2a6aHjtGKkssm+IQcasey3p0N3ND9OnTwnEG9ny1WAJuaW8UGyTzMp7hKF7UOQucyqQC2qOVhu1PMOYQ1z6IHlkGvXtj860X0HTVALT35x9ja8XwH9xb4zsPVXjozYoAu5Do83yguiBfcNSBJmV6STVmHVgm7VMc0C65ZWvb4PWtoKrF2DSEGld1+02vv86G50/w9ITNo068IXyeGuB3IQTe7XDwzRiZbCdFyHfEiZ7on1FG+rLeFoKpdSLY4C/zHCw7EcqGdet0TvFxMvMS98m526vCP08eVodhEIRa8k+8XxoFuXwXx5FYN12uGtOnQWOfP4cbeNeN2OLvFTEPgXSkHDlTrJgKMJD1bzHUhCMN2y1hLkwPn73lmuifz/XQcQo+59kadIts4AQCuaYz/uR9ii/hcNneQ3FLSy4lneHFoWiZ4DoP3IpNl+V4wYQYdfAniSYtYJIq8S3HP+59NzuLoSXDV+ySjgSXK6YZPXmgapMYFp7F7lytD+t8aZshLz25qEt219z26+/jk64vwb0nPMp72jrR8DhUz8ou3aK/SX0Z+64cv6iQ1C6CEg0o4+arhha/o6UHtUTATQc0ceb8PUNeaJuIb0yNk5tW1GckYDzdnPScU5+y/Ca58dOqZKxgd4GK7Bynf4Q/zEFONe/+Pyex2ze5YPJrJW5LMZLUS8WEqaXy9VOU6EIoxP/ufzUjgPjvzPHGRMBAqhNQNAVhx8/iCQuoMRFiRiyeloYzaOgDG2tHDuyE5IAzqhVwf8p0b2AhQt3qFMS9w2qSBUqFfXLxIvTf1RusxIEhkRD1u9mmCnVVxGrpuMHeOLI0gJ9HAjqR1Cy8UX14omRq8HhRDQP/tjdUhjCdw2svGUMi4qQZP0qqVAGPqwkeVtBD/JR3hxlFLjrKtgJjIvXGazsX9GPYGZoCY/WxaKf6H86eRo874ZG4GvwYLa1Gv6ephsjc9WlvuntRinjMBEWcj/z8AT+zcV50gDk8HD3l/GE4kcMlrqLjyBJfJ1mvIlAcAntaCF5EmXLPSqkhn4oxOOP9ft3Gj5lOtFyOiXrToPnyLKisPcLOicEm6sj3zEh2rR6ue86TQMnJl2IzxJ5i+pGmwbYUHy1vX5IaUKQ/H+HPO1WjblGEr/EEP3Fjqmp3GhHMFvkCye8ldjOPNfIAF1mgp8WO+dU3bt8KdwPuEUFFY5WJfxhY7FilHQV8ftwLnewl7VHO4agdcKosJ6NOrR24DSoPHavXkR21ybmYskKkpTJQYAvQuVq6M1HSmlP/cyH++Q8PWNsRHogCT5N+oWeZxO2AJHP8Ouw1AY70qGVWtoNI1HpmRuQe7r6noHrQ3l2q1N+ZBvQtUr/0zqVQNtDjx1rNDBGuXNWu9lm684a5S/SOoXB7qRk3/XRo4D6ci/+o78LQsnmRDT3Zir3Rd/yVGUC+7Lss3HHocOhlyImLK65SvhrPANfh8ApJKcL7OitbwXLSW6BSv0bFBjYmpoH/xRaDaIVq4IFIDNj/4FeUJEMkvKG8Z3i7fVAntfYO5AgYR0nEPafEZgqOKv0K9bYIC9ZJ2/rU2o59KhuRDJFqP9Xkn/UQEfPDs694X5T+I95egacPe0pqR3h8c09NtbBH4l+A7a2jNMF4rugxP76DHvbFQeXG7JPRc19njOaLWtGod0KkhuaqyvrDmGqlb1sQY/oH8QR44ZwWuKuvvLQCLWZe5Xb5uTtB1fnvkkL3JPGSNjiGiTTmlU8NIMVHg0DMzouseCtTR9LUuGeF65OrkXEl3LSVIgtOMfJ935B4UYVBL6Lx00UcvB7MA71+XzWUNVQzR1POcmEW7bjC/hUZxmf6vfW632prikYHkNVgUWZ7b5oH1QsG4l149uZSl1aJTz8qEEPd7Y8u89eWYm5kTQzfQdCovqrRpQm9hrtikHQ9T4OmIInkmats4vr+6JetMnQoUsN0l1Y/F5f/gYo5mbc0AzHvs5Mw9nZSktkFnGObKbQTXZICK5ngsD4No82Zb8Ok1IDlB8k2a7134qm2G04Bd3dc2jRB8MOlsdFJYraiN23VZU/XvsrjbYIOV6/NFEuDH59J4iXRYElXQCDfZpBlpOsXT9kOEXq/AhVyjgHjSL1vs/2kqKSXYJPo8ISODB69V2KDYwgdsvgpL0IfgA7izPoxlbebTrHhNt98goUHSqi0z2J0HdPgNKlREDWg+vszrcz6c4UBmiclFraqj+3mjkCXO33ebFalPwRSGBO8KVua++3bJepqT42JI13NNLNtS93rx1zALQoFF32rdY5P1lLhlAG/mOrGz16pKmYmLG2ZIMSk2HFnIeEfadS0rxbHh2tEPXgvC4U7NHFu70wp7GdCWOZd2m14oFMLZTbYtrTkGWDbDDjpk6hUr0M6mv3gI0RMBDq882Y5WOlsRCdOHKQtL75SHXYNTQLZ78QKWQtJ+EBBHMl6HyCIUivkKM0SF7kCeh98F8I0vTtBkJjhqLjvGw9zyS5HA3gJ3mqfwN17j+7+7Uu8GAOvxGn7zReUqCfRzS0ty/tX+yW6MZ+oYGd6pey0RGZ4lnGCxljJygj261Tg4Y4NxoZZblZ2Eyxvq4Xa2QDG5L9VhCxTKuDPJLglyGO1ZntjV3QtwAf0ha5JrGky1HmJp8rno2OvA23iizy/TkMB0pXSrr8lra6hi/L9xbSmTI7FOYMoTAf4JHNc9da4Nd27N8bqiqKpYmJAGDedfBkx0t1kT7iEYXVO4BKyIQbHvK7i+W+dsc+sISoFSlMvEQI8+5/9vwWluc0NT0ha83ULs5521IWORGYsTiEWUOmFhhGHc/NEHta3utPlrlj27rBrmwgMx+sB2Q3gjOifZGPu4aSDl7XJm6dUFSqi06YrxgdUU4QEkr4n+1PdK4lEnCBceEof2utzf/Eaqu2SG1W4fHnIa5thWxL+5fUQz/lEKjcSQ9YOOhIfsjXL8njUMqaNadkHL/dLJdt8AQfGqklMlopglnGqAzfg5fuggrHSn6IffKx0LDefk7PyaUCMM+9kWMqpD2HFTmna26yp4wI2qvkX1NJAdjBArmnxKFEyLPuzO1ftMNfE1KBFAeSaxxFCfpVcalqYdvzJIiBWs6Zewq0jd2X9Bv7V7EtV52ZN7RYuZE2t5SRh44vT7DG8+DyBVBoHTs8m45fxz2Tj5Qrf3kGPxF0EemIntauHDj7HuRWdY/zzk8aNcOFQb4wUS3URm+8f//W+DWCBqrZwVpkBqDp4xD6Rr/hyQs2/eQxJ2EBouZQ9qq1euE/KBSQLvWjQxZkmb7a5OIH9pyFwO/89CwqIRIPD+oPex7QwBEAC2fmdm5Awe8HWlLL5QzIUSKaOEoaC79ra1U9XY7rjPxhYwcXnfTruvxPxmHkFnIpmONK/SybJxee1oN0cTN6qlEoE2VOfxuEQNJmiysiYG1Ltt9hbCbOtMB220VzTVyQZHYsDAJBK2u67Exihz3v9/vj5YVA+/FE7Jby2fwt23zEZaNDmI7r+Eu2VL9DrPUgfrlrUJ3xFZGfozt+g4grbWkbiHI6+RPP18/kwrpP/OfKg7kR42XKnNL30bTUviPdWDXvhEL7aWrLJFBO7ds3gFS99iKUBoPilBAiUitpuaeRs7/eqIkR87YxCu47QzNvC8cBuYlOoyhmcBnX0iITiwNn11x71KPi9Gg4A/BDgEQX/PNX0dLJ3AkTMhSC4gS77gJuHy1erS1N817uW1sGcEAlJ2QNbJaCJnXAifbzwULrjxshHpj3RVL6oi0zGyfyUtWhJiSjM9if9HAM+tV+0y38QtRNeQ7m7xVbEndPNVeEnDBQWJ/MgReV33pgf21UMj7uN8k6hNYqyXcRsLAylZs6/YCvsGZ8SDEhqQ0Lv0ZpcjOvoVoWRRk9nUGUtXI6pEZmJk0QVMSRXMwhNBV1PZqtM63PlQY2+ozU/AdHGLnGq+CWWKHoatMmWRNOiNxBtfm1fkwChhN3aTYWpjU0DqkJKeR0aXzljH7JUN8ytXjSJv9liTy+GcV6T9BK86XS9J8sN7olM74+dMS94xGPegRGUzc4F05+bss2TbvkXIjAbejpEYycOnVfskpaXlaIvMvcU4FkP9YeswY0sAOz9ITuImMv6m/Me/R7ySZlYj02jNw8e2s4IDh48mThUiIpozwtG1iFst9JXQmLs3X9WZwfRzkOiydvaHrbSghxHn3ktB311yVySwO+HnvhApFRWS8BvJMMNxvE9y1KyDfZfWtLeuXNdcmhowA11oA402WY+mF4HwD18LR2I/xAnew5L9QpXIy4VueNfPaZTGcIco197F0Ntm3X+aJGE3uTy8lDgn9XPP7tccAGlH8BDZJh0Hfo05nVi0muWuGKqhyApJjysLBv4TvSEzKXyjvF9Ypr+ZCHRI7CVDG+FoMmso4tL+wg3vpzwN6qIlMoDtvF09FCnLdz0rVxAu/9LxAqdmWZMGBFYfVPBupr6JXDp9gtO+DUs/1pRQn3fqKK0iRm6n3vw7b4E5hnoQa2n79srrRY9FsqMMBGTYX2w1VkW2fM6vRz/uAuiKNUAGndyZea49pC1l234PopAZHoTDcxmqvQBg4EO3jvic/oOISXAWbHIhks/clz45cK7SelzUps/XJt7x1VG2iZWdhIkCeUMIEYKcnGq6p0azWXNJC9uSZtQLRQoX3RlO49+hHVRbZa56bEHuEWz8zOPll9DIYHEf9BX08bbK37m5mJ4ZvbGucSZ3P1uG8nA26PuwUSpoLalYiy0u3BsQV5BFnEiiLzayPS8VlYavv+EKXztoZYtTtKOD9cvuXaTguY3Qik4mXpS/YO4j+IExqfpf82mbfeRCFwwNvB5iI3NGQTUViV6eU1SFzNC5uvVs39NXGg3Xs6XBtk4xzA9ZJodeD59GaW2JhnVx3EcZ5okioD3NxrbrMwNXXtUhCkvCmjwxOiemMmNt5GfHU/mGcfm7J9QgpjmNxWRaxMlLrayhzZnE5dNbqtR/mpzwlNcRjm+RBJLgPTeVVtXZCPf6cckziARkrJoq98gVeqZQ8eWT2DAnEL6lgSZC5WNu8NrEGv/69LSs/lTGzpv1ol9NXfuG0DmvykCeA26tm5k7WXp2cv/eU/Bt9fbeYujCkWh8py4wfhWOVzSQJyZ6LzM5WjoyZMXqhiYAYdzE0dd8bL7fOa+7piHi+DUxu605UVi9ivRk9DvUBlqfABgKE9ujQhYX3tM7JxKt/itUn7R3gjBjE+3ijMtETTGhyumDorfhD8i++pmbjitlE9yp9C8GGI3qRyu24QBt0+YRk3uQWgZ4JeL+Qrngd+tGx7Xr8fgefqluZuXVu3M2qTMeGVJqtRreENCxhUJztEldfGA+waQWLliP7Ol25aBwDXj4qrK5iA0QYeUiinQczcY8itogqSGSBOoqly/bDb85sBnhrx3gJtdoldfHzcd1zGlEEkNNNpZWn7Kn4r07l6s2AflDhLUAj4iXmpafWu8/rfuaDrb8JiFuQt1UlACk4610a8wcEP/niKyme2V3gcIpQ1VTEoqI3t0GnZ+E9U3Yc/EhQvqGtAA5+kIgvBEyszcDfY0+UXCPt8b9Qm7blxPHrDFSm2US17ADaVB26t91NjRv6UJvZ81zcTMAQDM2BpplzOAcET4X50XgNa8RYTBfA9tM5Exj9BG/UF1XKeW8Y/TXLv50Ucu9RZuM9igOClzHgAP3PGdKRD1fnfi7xBPAuc6zGI7qAAz0u/9C41sbev9z/Ed1qCDlLOtmKLUj4IGt6pAS1rI2PfrhI4hrhaIIp76TIyFXb+qYTfTuGXGFqjxLgF/6I2aWzTfOFuuaw5rzwh9p5mg0DjU872swxtabHvu0tcKWKgEGVqWfpJSe9Okmvikn9pkZL/uFk/T2aez/ChenNNHKZEYJxJg6Vk8ccVcH+O6dy+NsKDgq3Zgsi5pv1o+atpGv7fU0UC2V/pH02BSeaDygEb+hwkaHns7EfG4QT+GGNZecvKnnZRI5C7vTNJ5xxKQkuPegHQMRI3BOT+Mow6so+uT5wUeKbJAoM9vT24Gi/5vM8arwnvlabSe/cqrsupIaTW4JDxDQSJ8ejwaAE6tkG1HIZBkV9SV48tpwFAknsiQEN1ARgxkk4MGzMKOMVXzgMYAbl3PJ4wb6ir7JQdRS/NkUvHFwCZ8YdDwiKQez0WjFRPiHAtLSG+IIZXI/7Hm3dV50ZmLXgD8CJzIh6iRufS8Nqz72mR12shcCIAQ1UnJEykol6mK1XYm3cBBr8st1VqhGIIOPsaEwkF21ImVMW4sq4POO+v6p7DW1EW6IB1bfFjqNOaCbLZx+FPZ6NrYu4qxYI3PblI/hM5bsaW+LyOdligIruqLApvHFhe1RYuCOPo3+uqzgN8vIYRhwlNWSFibNieqxqiageCQxOFHIuy1HkmZ1iFlJJtNAPtUnhIsaKUAnIPBbDVvazOWnd/etcAeEYSMoOQCVcGqfoSZyLbPI3edwDNDy3nR7KpOWo8IpXnjoI0LGX83ZVyhJWdbVco1EJI8MLXnrJgZli8MYzV/AUcNQYUE0PJMWQlgEVX4LLxHoFmAqlz/0djkWBr/15cWJfriU4wKkU+vE2Eigpd+kliAXzHdtvfRPfT/u/iixR2ySBOMwXcbxIA6zGQhPegswz9h/mtPxLbn8OIm+YcBOF9tuyp4IQP3imz8KEJ7lI9JKc3q7sQcludEhDW5ddwI8FJzx57/Afxkqo/H1uUCK375V+f5JDc5AN3xHiLbDyDHVQ0UUzOEijOWlTEAh1FPu9+OB7R68UJFiUBCpsSuEKHgLPzbVpCJjNokx+sW+tNrSH8jyVnPvqh1gFnu+pRFOqa75+2du9kHhyHtUTG+xrLHrEGfRymbz637OC3EyHHVI7t3slk6zKBtaSOY+tU5P8Fd2AtY7fbdGjpTLvOpn1Cbi966Gg/a5xxhDWT7TlHIQowfl0URcL3mLx5BzRF3Wk/Tf5+cHPFTZfWqkThmcZLwbtZhFhHJAeu6alhCuNbqvulbJzmqx7r1SRPwlEs86GN2LJWPsafuzPKDlO8F5Ynmzv1WjmtLKMtaLy0eslMTGGFcYF9OEZHPHcUwng4ethfschH8C0gZH7kbTb5R6LZS+VY/0t44d7QmjSRzwUvNN/YZNPNBoZs3qFdxh/6YrnTQtGrq1tSWVf1NFZOF1pQ7PuV+HgcYLPSP1gDnT88b8bfuNK/W54DxgTghSde7+YCpAAhhAuQmVlF/miVOD8rlgqYMri848EQHUBoWJynxcNeSztkjbNOjgtKDt83L6iSF+CnZXKwVv5WusFeHdbM0kpau3ge5k3BqC4W6NsWglyZvuJ20MQKyLuJO+dilVZB2vXlTRFMbQ9kH0U+jQMqlPWs816rvpK4JpTktfDTKr0aSIDxRbjfJlHSNwWL8u5ZGirOIszHqKzkx8cMae7qeY+osWxTP8gEhU/1x4mOqgRwgPGeJhU6/eCgVGwJciBN9FadcSC2eKkMvbQWkHDnkgDoEBIYo8MvUgzKyy14AXQRSu1Y/T9EzYhXrw7LKKQ8NebeiTYBhmjGk+q0sy+IakU1JCq8EfQR4lWMJzYBU22Z11nnZomMlVa/D5zHbyBqhrz4Igvo1hGbQQYA2NnjINtKUv8fPNOzPQB+f71p2NltNaTDjpa10MIdNOKamh+1PYhcrCnZpCn3kRxtLbgbuFmiyN8AiF7GuQdqZsHqMIQsfG9IHc5JjsB5/Ag3DXpWE/9djCWtotlmMjvGlNZsy3dY339j116o0iMEa7cy5fBLKSjmpjCyE02DtAmt1TUCroc/liilNPPYrwMokIyRqy7EHryGvx3JwlDcdzEv1TH19oRGv+N9TjTA4FUztgGq51Exhy/wL9gx8rHNW8nWhGFOj/38zCoV80mz7/elXfjjOYH1csef/1qxhM4xbX4NmfNNAYKIyHirCg9yJ+kZL9v5pg0bVRLKLwJ8gRn5CxHs2vmGeLCJJhxknJyZmxCt5HMz5obv+NLJ+GOLdATFfCW/+lisvABPutNLyb9iTUibedVkd8Z60ocBMRmL85aZWIa/Sbs+JPz28P8d9hkjTi/XGT+tQ2UwjJ/31MexJowbHQ594ZtCbbciwcQ8wromqD5ngMBEO9rSG3gRM6MyWjO9HApW4cS7xS4P4P3YNw/C/T2EZA0bV+2mmTGtYvX8Wb/XJ3ZR5Q6BG4hV1UmnVODUyJgMCJAdcnOrFtgd8gBy4Zs3jyZD8nrwaw20J38l4qKImTNT0FDQpgGPDfjyUKB6npzvFw9cRmiCR1QA+FPh9bxzDACrLRqnnCcFQGAcDtxVSYDbMsSihoOafuCGULtckxqvxdX+FnGNbpT71wiaBOOhFvCXaIsY1/ALrgScSdH3kcblCbD9/CiqFTjLr98QA6X8bTNGh1lDpPS4IuPlS49h0vFcgS5MAtheZAWD3p6UB39jkBYOtXAWpjaFvgTS1otbYiftRhTXcC0Y2GpN2ZTJM+kdpj4Jy8Vx1UTt2R+r4Zg1Da+EqK3iIVPwaFm07/B12ASAhqDKsld39+9nIDnh7jonKYinXIyOzf5w7FRM+95pTDpIU6bSA/eBPePwFxNlPiSEH/Nod3Oi+CmmxCGx+jdtmiNVGZqRpZJkrofVp0bgPClguTy7+fayD/lNQq7TrdrXfQ8UoNAVKNIX28ZiK0IMC5t592ADzmBYSAeY+4qrpLJ41tsPXEfqTn6QzTkXGtVCVxy/0wAd/WGyo8kaszNG3yfHPK5OhMbY8g/tUPP58oReRNNtSnP0QmIjuITdgmwz2yrOfXe5UJ79kJB11e2/y8gatFIQdVAyyTC6gHTxnmSDf3iwMBWLP1pTgxmHQM2XJ9O+1BZk7VkIO5UJoMjO3sS8+pqN4HFO8fBHRr9q3urhCGp5b8EVvvserCD6MS4ysrnWd6HLSdUaN7EOMJrECg+uK2aNaAlCF3+/1nlPpcPoeV/+BgzK0um42Kg2nQXSJQnLCrUMjqDmTORC8XLWGBouF+SBNEf4KEVDPpMk72AfsEPTQ6aaTehlqqI6xvZ9HtPagUfYx3ixRthnLwA/+OUy1I6fPX73/eMYGHnwUsnmRZc2M5TSJMfQv8E44Pna1f7bhAA7+HX2OJpIK7UaEG59YM/ZOdnAi6By5ofzBXV/ay00jBndbWcWA5eayBklEg7J5yXDW/2gvUaQJrHqvU1g14zn3nwmOb89+vWWExenqlRTFIPOTt1pIDqywAfJQeHIAhKJE7QZAyVuUtxa8Ceh/k9mwcg+RkzWoo43GeHn2lliKu0wf7tIwVnu0cnTLA5b0VUHPnCU2kwdqJNuIQeI8Midj4yJBf7ZA6SSD7hwiX+SPLmIY6eCzz/HhnT1kDPcKP5dwhBEIhc5uyu50hfm74Fg7KSFuO08ROb0eJBaS4QcNfpiYm4vjPHnVZHLj0PM9JLF+OvvfM4YQ6KMF68zgO7Gybije9O+Z7daqirvb5dfO4qF9XN+4jLPs/IVd1ErwtT4W/Uk/yikpKAdKaHMYTFh9F7VOD0FK5tiJVDu1+z50hKHtuWSkvz9MJuhrDUsqyJ0MMw3hX4V5C0RRxISA1rQTN0A9TERsIL+q5+742g3v5e5FhSx4iOLcio7ckCStxb+BMO++6jrNaGhcj9t+eWG/vMz1jJmwNEfM6rIpXM1Xe3MKv6qd3lMeHDqy4sjCTCVlpMASmUyF9RrYFfzZqjvw9AY5zZw3M5s8h28XfZ44khGMNPRDVXn6VYpyfNMDGmDn7IYZbCiriDFlAXivLCQm+8c96QJZ2hkKti9QO0WcFi18OeKr1wqgDDUwTnSXP9U/U8M+hI7gPFrqnpET0cNQ5CM6azkRHkr0BUoRuVjDzw5rGkSEZLXsdOxOSYSh+a1rqmKIj+/zWHzSm+96mQhPwGMrJQO9wyUif+Z//OWUrtHic0egZoEsrlb86Qz1v/VwwoSgUwcSo8RBg93IfXEhOK1JVDQCZ2Y4fx802R8QXLSRLj1Jow6iOW+BlGCncbh0xWk/vMgf9rAldjHYP3whq0sILu+6rE1/bOcTVKDCZNzJsO9fyKdmhhGiWkse8KaB+HXhZdjfY06HCwnjwwJox7/TR4+J5aLt4JytHZgMkXMt13u6DVHaLISicRH3nl08EE+YcWCI9lzvas5W0/NkZ6ZIy1SbNUq7zbm3GxRp6ZCUb01Wqc3mJSd9LJcOCyYiAzeKcOC99Dh/+x+2EXSeeYYaskwQu7xYpPzWki/FNJIv8QBtpfQ0cobhIoylT/wxOeIt2Qb99WSEGS2BrhhIYPfzUSQ01VvwhS0sRSKQj+DHvzo1MmxahyygjFeM8G2jeB1YrZF0ycgNi0dJZ2ToJVo2anSXeNrtP+iOS4Kjw9oc6o2++mm8tgPqYHSIx93NwJy2NivJiqI6obwl14k5AqWV5b6VBZ8+s3IyuKWtzQye10ELX4gs/WepZiiKw17OlBWkPGjSp+uktGRTLRPk3PSVgaZBDrgDqfMu9kBHnLGfruYHdVQR+I4bvpau1Mo4ytFaW26SXyloUPvwGu7DHke0rILaXSm7ZSuNbqpb9Mmyf5QQOIw2GhUwHJAn958baIFoKo8UV/GC5zj9M9WtM+PTGW1dcThxGUhk5yCfkxa/kcLWX4ZinWSMvRVEWmQS2U8yHdkQQxsljnrWHTYVsGls9IqQ/jUxcxzJwCDnxfIghzgxCSGO2p+fg8VWsq4VIJZ9Q+BpvTOeCe+As9U25Xty+fcrxuu0kGtTd/witIzo0+I4ux/XUT0rmcdNhXkpY0obc5s3Aus2mqNFG+sKxnk/VyybClemWtdBwa1cEZv+DldZQVlBupoBhBJ/y9fPeHjAXQLONmZiskM/4oRq3XX8Wb7zP1BlmeqVKDSFlCuZqy9CMrVYUE9qvOMc4DV8UPUwoI/omSjgXjV+yZv27evOM6oBwMCIDfWQZD/eB93T6LC2JLN0N5TOVrk/ZhVFxLdrn9/IWPUFfszlAQ+CcfWr9TzzC0AAMaaGOkMSMtGcRiON3SRGRYmNT+bkScuJtpStNBF3lLNvEhAJOPCVJ/+S0eQ68D8P2U58Ti9Iky/cAz2yEhcfhfnIEwgNNQ4hXLH7g+kY7PvwtfjKY+oqs/HmHHQ7LBydNWr3MW55tm1YRT8UPUKUksB7oZwV4GXlkm/NRVi/HeyrMbiHYj+HQ6Dzs2iAtU424qJm4Fi9QkD+NlC6mc8AHf2kQgIoTm66XzxlQZgGLmMxNZAZY+1Eg+NXXmceZdiDoYbKTaW7DPTkhtwOBACTo7Q4+ezEjXfEXcMXU0hKthkEXbj1p8oRTTMBmZVeGO5kGJadZ3LiaSZsaZlt4ueVb8iwVdpSK2FCH2CjV+GQbg3La2fZ9po6vSABxBWzznWeF8PdmA10cag6r24kTcH1Om4atpWqiBerxTNWdb+RD+TmBGoxhlcWlZxT0BB9BjgcHRx3ziFV3rQM5EAobAg458cF2Yz26JLtGD8EyWdr/sP73aZyEn88s651tTi5KSCfa31/v2vGNX6L8GPmWTIV/rbQl4JrrzpCqkWIc9CpWT4+mzAC7oRlStCjbA1+fCLGOMYG9MR/TZU/RWjfhNvACKn4LdBqcTrPB+i7zivrDJSPqFDAgG8nMAp8LXIGGAgk7J5e4A3yFqanf9lxeBSkPlIXT0ZYkuDzsJxoWdPcVmlb0knGanjH11ycRip/VbwDTrbszRGnn7pL2tNvBU6kSLipSOFJMiyrY1L2G9Q6pPv2JAeufanHDanvvMLal678/1qI4dVjtUMT/PhkzA7QW33ORFtoj3B/Tzv5e2TIV/PJD8khk/K1c+gCYAiCj+uta+43ZdiQCrzgONeuiG31VXHBczhiHWX5VK0uJ2gLEpg5IGqCRfpqmYpJg38OpCzqlkSSJnmS1Cy++KLATynqFVBf5ZTkYFsPBW/i2zeeCS2JBI49GM77WwVtyTXxR55adaruW33QoPSGSC+alYzFvo3z1eDs2Xrmkro/Gum+dsUTtDJhkmo5dUZZG0WF1a3RzEULsFlaeind35yL3uzmOGWn1LDq+S8TfYTMAE/Hh19qR8YcJ1fos3ktrmnXzYFYH00Og+5Xd61mRXUuR3AI1YriIdyTvViRWcYumbGwPv/9x+RiO+CSR/dYMg5W8GQCjAOBzmYUYKQ824SYGtoG8GKiO01cjKedKYEadEvS6fGnITceRZZ9pPbYD4E+gXT2AVdgSh+zK4nskG34KSqY1W3sCJFhw0r+uH/TWA+zNGqqZJE2RCqpVIQOZeSvYZYGDgVFlIl+lQpEYUChkhH9D9PwdQcYdhuiFqFafvKnQqkzoz01CAWBWGgWN6dWhfYqxNAVkzI4bCrO7yJL+6SbP/D2VYmXM0XPzu7jlFnmDrytS9qsWnLq4B5TSz81LMN2zMf+0LysUisTsABtJuvl24Cm6TX/hV0POHRoedDbH+QH6fMXc72kUzjoT8jchVmP95ApCRwzePyPyI9LBSZ+lBEMSi/pj2j8Mn/nZynD4bczTFayAimpo9H1aHI+0DkAgbxQUn6y1xySeG+EUKx8To5zUsDJ9tMjgI+s/V4E2nbAwA8FDgon+E8UICbOKZY7kStNQx7JJ5qfLtb+NA+8OJZou5unge1LUGnnEvU5JbYMcKmW/irppd9HZJGSmCxNADF0UKlO5klhA2di1AtnUrgrkXZiM3Mq0M07dHj3Db3WXHkMsHLZOXiQyVYQpUmiKOm1KNkNYUquJV6P33KdWnd6lfbmRiph1SIKDg5G/Iolmy68kMmJVV9Nk+XUFhrKZRWDjARyPFikZA+lqLGeT1G5KJag1rO9catrZ6GvDLDeJYKESb84WW7Ot0T/2NM65nGUDJNIU+vLqaAQ3BPHlWcyutyBa0DES4TgP1WA4/FEX1T4vyg3bs0m0uU8GL42IdC1G6VUIXUIHknwcQPMwg2tfFahgQI4iijCFx6eePecPig73Snh+lDVus31mgqiUR2e6OaA35uW4ZocuwSI+Q//ZkC7jrm9LHLQPSitEoFGPwkorBOFGd2ylwgHoqBRlTtHq6u69ZX6/klQdRHvM4V176s53lefAw9P9hkpdH4QA0BsNQdZj/09/BrfVu5h5oxo5Opflrdfgfb0IvPJncfDM5JTuVQUiTb+YR3IXrnVevyKRUhXlY8MAJKBu8j9WfQPU32Iwn70ecQq32Lwsf1IK88DOchNV4fNYR9HIqQWaxuMMsrqZbPxDVmLz+FuxhpVfVWFWy3A+ArM0FSvljZR1k7Ihfwehig3t7HlluNCA4yCABwm9ci4p7yACKd4dJWuxxnkKmqCwsrZoqcJVj5HUbApDHjTyGHTKC88JFV+LHiFIzftYyjE5k/0ezoleGGf0neIDO+E6fJwxmLuoMc7RD+gBql26vA1fTSqEi0MLXzipEXBes9rai2VdXrdahPZuq7IRbFUFXZjhl337Cbj3FFzBYtnw+h+ctCSVFpHncU/o1sZeoemxy3ZcsBJ763DGcLczS5Zi7RLazuxbTRAw/1hJ7ck/eKrhXqfrrHiaP+zLOyqv0gTnxkz+rdEUZhtTcaZ3RuqjAReLeMwVZQpS0WUE2Sgi7WBt2n7ndF95li58GMIJRda5WjhSttl81a40DL0T4Qhb1EcwecVkF+pyPD0GL0+8UhUE2rhzx5OHpQ+rWwwc+dBQIZvGpCFJpGzY4RlLLJszpVskXn6iKXZ4iwLlWJIG4jCfopM67uyo7y5uBCgQS8+Qy2hWHidJAwqtfL8Ss/xEO7ZQsBTtGe6IjPMwKKspZjfMLwnsUjUytinoRzCzyxhBgMcPwMW9h6y2i8m3DpVPqnkg58gYna99hqBAlpWyiR8y2Goc7aJWUuxpHMNLgugS7B1dRtsrLVnQqRGF05gUNo6fSEdjWl/SKZwdpb25Chuyx9XqUp/bxRjid6aiHK6LrZP6/Ur4QJg+WWB37WrHoRncsVK/j57h4QAeu8So4IIInQ1ePTgxCs2/7cs4DbJmglwGGo4uzWNC+pK+HRMflO5mKO8s3tjFTTnyJWuZGOqM7AV4hocSAxKrueyj6j9FYtmXiCS8VTYx2Jb26Mae0hQAughcWMdCoi6rYJxjl4t7/x2BHFziKG6mAsnan9EKJoFb7sysGzYbwkeSbvIR71D2jtS01M3dmfpw7C+h1FcdB2sX3UcUjB1qCLIiqMYSGoJG76Dc+GMg1xmS0a1PcqRLRsru5ZcTv0nqe0Ee68B870nPOHrGk4JQo4vfiouSv7jfGrPzefLAqfDkUoGgM1YukYNe3SaUyMBTGBvL/Ik3VCUVB+3QEGB8dHBrh26Bkmi5T/WfruBRmBxCM0vwPv6Io9VUu1vK6dQu85CrFLE7Pd4whn99HAFCNBaDeAj5UUi7Mx/O//QgdKkJQDeRnUjmwgUTty+OsjW0k8zz1xPYfWNC201+pu8k1zXfhKWMfnrAy4SituiM3RlGW4IkD0E6+ooKiPUryU8VaP8IiqII9KBeAXXZZpSX/J1BFcp8WVl3c99wkGARUv6bCXcFrB2Q5ISabkNn1eBxp2U5TXXeCGpZYeqOoviCTxEzfjA78KRoXOPFKyXYpQNwUMmy9IdEYKDLZrzWIYPZ66PmqfF34PYg6OvVqptJyUWU10oU18Dg11PO6+0fCSungJ+FjyIqWJqjT5sof9PJ79VdrDEP3Q5VIekyp/jHROVn1jJacZqxH5G2VgWOEXXqQk+LpqxHSN62maRsmf0UzQV3K06JlatXDRGPp5+8K2twAQ80zphdxcNlv3witbYKpO9HlPhpX854XMzUamEt9LPQl0blZANcD52xbjU/jNryNM+dXQMjhx2Sj5RqvfODLt9uXy47aWW2orbDsjI0Egu0l4jDVEiutgv13I9nmXEFjilGF0PiSplnXk74awNSO+Bn0amS+g7leFKaz3rVQLFA0FrhCmaa2H/kQPMtQlGVTaYqJLgooJU9LbvGWFBV+HFMt/YH84x7OzwdmNYIfp+T2S9/r06swbnJhtrH4e0XSdIlyEsqRsYohaZNZzZpHxNIhinThBygOnQSBZh4GE5HxoOx+lMoE+lapJf2BHdw7ysFJirpiE6kLzfp+MT4/Q7YORTf9vAzaWy7hCtqau9xL8AJ52Uuiuwx1WWvhDcnWX7gkIboUIkM8bYOom9897w7ipqP8kvTo0sN1LMHb4m/YApgbSt1IRJRQKW7JAmM1zY/4flvfdRPq/AfJeOyRe8WlY9SuCT/YjoJfYgCX8YllEVk3KpSEmQzqkwwkGnFmXtPb3tXCYg4Xsky83phBBMa6nxvTGHd9qx++3UyzP5YAbZKqg38ZGF+YJnVpjdC1hNVHjVDOIQaEayk+paHOPvWPmh1na5DRpMgfc232MYZfuTRk0vtEniZbDPswJIltf8RU08moWD7v53o6SUKxJrk0hK9BvtFyDqERiBxBq26mAvJI2A24XLlLy8LvDrYyAlGuek/zWlblg99kWNF8xAky1ypMbZyilKeqPOI0ZLf3wQrkaR7GFC/l3A2ojJOCUpGBKgti+g67AnTWOQEh2A2Y3AVafLesfp0DK6UxfTQa33DkOGBTYPV4iiyxOTCWGIBdh82LHTmgnEQ9HtzW24RKK9WkkUWVJnQhQybI/IP5dchG46DqhEFbBFJs/7+X2tysqnsJtJBjBR+1zvPRtUe33pYbw/1WsBKUCOi+RUMrSBtUOs0gLz7UqbLUfw3ZJOiD1f7LFx7RBSPhDhO8IrbmZxkEubgK38vx/SOm0vn8+aEs0X/K2i53NaeQ8F7nWYXovgXWOdm91+NkMBSWL9xeAZMtcehBf7tnimfpXvxsxJmhvjw/im7OliYLNNZAG1M1PAZSQ0TDoyGc9LJOodYoIMQoQXG6nSJGCH8gicBHpw44RSqYn3LtRCnvg2nZo95530P9jHA+IVLwIkRv/gTSJuEahPpKd5uYPpmsVl3JGgkJrvXNPkW/Jx9x9LzawefZASjZSzUY7rF+rIk4cVzF+SWTogrbXQmhrhjKQ+YFU8G44y5QRMVEZalvTtJLFnoKDlvx8AG2tnN5dgfKnlOiUiWYpk9B0VxxeC1dKQ2HNF3zjkDS9mOKJNPEDH7E6EE5HH2irYKQ7gDnPFFVronMavbgZ43Ej1mBfVZcF5Z9mHSS/zobkzBAsyxBTowPRfUW0cCht3WbZdxK7vf+rX5v/2xVOVzVGKdNQZcXuUhcYucEMaN4tql0PKojx1ZvNYrh230z8cSlIBY4ZupsBs4HdjXcMZECrL6D0tX1DmofaDZYz6w9Gtc7w7IqLWFL63oof0UXRi9Y0qiTKTlpu4wsugZLuQLF7uR9o6P+JedRo3TiW3tvrxx70lKTkKWfDS2hekb8t0HIQxdRMmCu1Uy6q74zANnttsYrNO210cMdNrc+E5nhqObsjdUUG14IIHWCDl3zvRAVp9tebAcsvOT3BdiPDLnqkx45CbfrxeNusZf6dZ89HweWbSCOdLlCZqbV//6hP4dedEAQbGC0XIWFDw7OgFAFsjnYLad27D8juQHYNKNiYv8su4tu9qIfU9ZaJNmDbLmBrm0spXUFA4pK4lZ6kGGrK9HKUbNMCOHgWiqFY2icnf+91+525q78iDgZ7QD3QaH8PsqFKsXG3vrYGgQt0QFvofneSysA0Qph7oHXJ912X9T1uW0TIANVffWdRtASQ/YR7bgx7jMtg/aCliSBlcnnobm7Vw/gsstbJZYMCmSLKht1ICtAI5Q74EsaKhgIM9x0/VpT/v+0a5BvQyAZCddA6XJ+qgVP6Ye/WdJDkZ5zJigLOIvGHX8C5vBVaolUoKCo4xnTRDk6DcULax4PGGEw/5zfbc34NwVUH77EKW8k1xQ8eBlg3mzibbrQCjmQDtaAlSW/ejUpXz4cttlz7MTrqv3cruortBYffySKQUKjO6037XKkq1mDnwmpN5HN8j1WzrLET/okrmMESZNmLB/l3OfRB0rXI0PH3xq9HBzWD5udAp1WJNEegqp2QosqjYxY4boD54L3G4nJHXB9aj0PtQn843nBryC5Fjon7BL+q7gcbQQmeQIgjBohoOxD+S7xvNOuJuWV8IfO5wLnu0XR+qTwn7xClRozFfDi1ol61J4UhKmF6wjRl1kCPqrZ+XyfLlhc00hUTw/B+QqEdwRtYc3r87v2kIhXKJT0IoZFl8hTNtSnhyrIu49lfCPt8u9eVc83k7x5kSh+XQzI84Cdiu0RDB9wguhfqibkCYhCwXHGdNYo4Yc9uIueyyBw+MPHakvop3ULc2HwVfhfxsTmqQLT6QiKW4xNmjpG5WhNgyD+R61pgRBIedj6C7so+u9J8Be1amLY+tRRkoeBO+SzFZUAewuWxYLAm2akPhoV/sitxpEeJAUXyfqKNFLQwgHUv9BClGKd1gwCZwC2k56ukVeFoTxQMaGLl4x4OTc9FLUAbr5d0ptB9FCiGoq7LBZoBsYrbnTk8G6q0EvS/RGnP5YpUK+YYTwjHm17kay40a/75031g88TiBW3CEK3KPSW7kAfp3r1Rfrc8cdNMOS5ojBrnSazqpyLBCXGTT+vHwrafXInjy6iKD8BPWxmH3pv3Yue0gPZGAPEwQX1pByUbk1gKtJd8mzLbCkryIaMbFk1/AUUzZdXq28wOC+uAgRE9S41j0weLMtdRP78O/H+IjSmImIbFjDuowYjOx9+vwGCh2YegxN1D05YTsHZE1FdlDjv5GW87NV8BUjP3oUQb1CNr4HcQoa09JRhdbdzC2vtq0TaCP+mvXEwQVPs3wNRXcM3Iwv3/OEcEtJYv43v67h1+j0wnjEXjyiak1CTbTE9PjauNZRIU+IgG0wayfNDTXUU+4g0+Xg7vI4aRbXYBOTaf8wQcRWXiwPZy/ojBtIWHRpc5I6VUVd8kGAh0yEtto+M4SM8wL1a+VwMxZTUofaROiSdGUkXrTeBgf51AFJ48Atduv4rkNGOuR6X72NSo0g8EVsJbAyGDCspM6EHSmyKfh354R5hcRJ6UcxIO8n28anRFklturoNbJYj2N2EBWzqVsE01kvIwCCFunZVMP7ScHkggNluhFVidbjRkn9HMvqZGQkjL+SNBeiLniTmO1X5zF5LVXYnn69wBX6I2YvSOAGhX54LdALCA4gxNm2BSygo6HJrNHexTR4TL1ZEQtzFlgain+4hPNnc/gLmBnUSy29Oj1ySMUpVwc8VUZo5Wk/nF5QtWQujrB/7HmY3b7eUKJmjSO1kSqL7HcRlElZNyKdmRd6k/VdVr/ZSQci9hvbcXd3KSYbuB0Xx8v9ZqYPAro0GU+/vqi2s4Z/lojXvCACQkQr2wBh72pHBVpg7LMuhgB+FDqAXWG31zdSdGKa4yl+7or44eJai5Xkblb0EerZzAjGXhf5cuvSxMlr95vBnwT/9ZibG3t8nFI5HhYhrhZnnEDvFGiqG1lv4lM8v5mil49HnRwnctezPE4M60bcwmdBgSnou72hB3dD9vAP6Qw/Nw01SgUd37RZmqikKDx/EVVvptk3IXe0jPD/yBGqZaRs3T7KPhD6R8aB6lZ/o0Z22la5DbpKtSeFT9S4+L/zvI07+I2i9odUc+5HzvXyTqoGuNd+HoqswRDe7sKd1gDZir2ZzjQ0dEVlNpL0l0fr6HiN+9b3x6vMcGpo6UplCaGwyG9t/wufwMJKm65l6TMrzAHvANSxuRh9j4H86YmMHckt2GyYiAoBb/5neHTIEXj+1BoIEQDIgU9udNEQ8u4nDhr9o0Tg9vhz+Www2vhuheRya64L3kT41yHAmdcjVN/SHXRxB53mG1o1gvppWaKekgPVOv3jAAAAIEzB64P16VhV/clR1cF4TPpwuSXBU/NuOM0Fr8odswXvlhTA+ORJEm5Ajh3flGKpcHMnXBSKvn/55DppzmMc+q+/zznPJ4tXVkFGUK1elYTaTqPd+82z1bzKcyrYcmzPGY+zyElICoplFtmtxkDux4bDIgANAdjzB1JWVBbIpfkHp5Rl5FhGw4/WDxUew63K5apAv7rAnqpIh1ufWWQytdRU3YprzpaR2Rdk2S8n3abHiex+5h+jOtR+WFJq7BH2EV/oX3SFgLuvxNAflpQfhhI6ZCuw+CYFwa59gEJgNkABwsBAAEjAwEBBV0AEAAADIFgCgHPKOfQAAA=; VarID: ---
Type - Grafica - SymbolApiHeight: 0 m; SymbolApiWidth: 0 m; SymbolScale: 1; SymbolApiLength: 0.0009 m; SymbolHeight: 0.0008 m; SymbolLength: 0.0009 m; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_E_IguzziniMod.Bg19
Type - Pset_LightFixtureTypeCommon - Reference: LFX_E_IguzziniMod.Bg19; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Altro - Famiglia: LFX_E_IguzziniMod.Bg19: LFX_E_IguzziniMod.Bg19; Famiglia e tipo: LFX_E_IguzziniMod.Bg19: LFX_E_IguzziniMod.Bg19; ID tipo: LFX_E_IguzziniMod.Bg19: LFX_E_IguzziniMod.Bg19; Tipo: LFX_E_IguzziniMod.Bg19: LFX_E_IguzziniMod.Bg19
Elettrico - Circuiti - Dati elettrici: 0 V/1-6 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Quota altimetrica da livello: 0 m; Host: <non associato>
Name (LFX_E_IguzziniMod.Bg19:LFX_E_IguzziniMod.Bg19:...) | Contrassegno
9583708 | 5080
9583741 | 5121
9584286 | 5149
9584369 | 5150
9584388 | 5151
9584415 | 5152
9584423 | 5153
9584431 | 5154
9584439 | 5155
9584449 | 5156
9584457 | 5157
9584467 | 5158
9584491 | 5160
9584542 | 5161
9584570 | 5162
9584604 | 5163
9584618 | 5164
9584632 | 5165
9584646 | 5166
9584658 | 5202
9584670 | 5203
9584680 | 5204
9584692 | 5205
9584939 | 5211
9617303 | 5982
9617342 | 6117
9617343 | 6118
9617344 | 6119
9617345 | 6120
9617346 | 6121
9617347 | 6122
9617348 | 6123
9617349 | 6124
9617350 | 6125
9617351 | 6126
9617352 | 6127
9617353 | 6128
9617354 | 6129
9617355 | 6130
9622777 | 6132
9622788 | 6133
9622796 | 6134
9622806 | 6135
9622820 | 6136
9622830 | 6137
9622842 | 6138
9622850 | 6139
9622858 | 6140
9622868 | 6141
9622878 | 6142
9622888 | 6143
9622898 | 6144
9622906 | 6145

# IfcLightFixture: LFX_I_GewissGws3221Ap940:LFX_I_GewissGws3221Ap940 (96)
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_GewissGws3221Ap940
Type - Costruzione - Mounting Place: Ceiling; Mounting Type: Surface mounted
Type - Dati identità - Approval mark: ENEC; Descrizione: ILLUMINOTECHNICAL CHARACTERISTICS Luminous efficiency 100%. Luminaire luminous flux 7473 lm. Controlled symmetric distribution. UGR <22 (EN 12464-1). Luminaire efficiency 133 lm/W. Lifetime (L90/B10): 30000 h. (Tp 60°C) Lifetime (L85/B10): 50000 h. (Tp 60°C) Lifetime (L75/B10): 80000 h. (Tp 60°C) Photobiological safety RG0 unlimited, risk absent, in compliance with IEC 62471, IEC/TR 62778. MECHANICAL CHARACTERISTICS Housing in transparent self-extinguishing V2 polycarbonate, UV stabilised, injection moulded. Ecologic anti-aging injected sealing gasket. Diffuser in self-extinguishing V2 polycarbonate, photo-engraved interior, UV stabilised, injection moulded with smooth outer surface, tamper-proof opening. Gear-tray reflector unit in hot-galvanised steel, painted in white polyester, fixed to the housing by means of steel rapid devices, hinged opening. Snug fit snap-lock clips for diffuser mounting, in stainless steel. Dimensions: 160x1270 mm, height 100 mm. Weight 3.1 kg. IP65 protection degree. Possibility for technicians to access the interior of the luminaire. Luminaire with limited surface temperature. - D - Mechanical strength IK10 (20 joule). Glow-wire test resistance 850°C. TUV Rheinland-LGA Certificate for food-preparation environments. ELECTRICAL CHARACTERISTICS Electronic wiring 230V-50/60Hz, power factor >0.95, constant output current, class I. Power of the luminaire 56 W. CE - IEC 60598-1 - EN 60598-1. Ambient temperature from -20°C to +35°C. SOURCE 2 linear LED modules 24W/840, CCT nominal color temperature 4000 K, color rendering index CRI >80. Color initial tolerance (MacAdam): 3. SUPPLIED Fixing brackets in stainless steel. APPLICATIONS Virtually in all environments compatibly with the emissions/atmospheres compromising the use of plastic materials. Not suitable for installation on surfaces subject to important vibrations, exposed to weather conditions, on ropes or poles.; Immagine tipo: Immagine raster: 3ffilippi_58809.jpg; Modello: 58809 - 3F Linda LED Trasparente 2x24W L1270; Nome del tipo: LFX_I_GewissGws3221Ap940; Product group: ceiling mounted luminaire; Product name: 3F Linda LED Trasparente; URL: http://reluxnet.relux.com/search/artfwd/3ff___58809_-_3f_linda_92686c2be9a40892/
Type - Dimensioni - Height: 0.1 m; Length: 0.16 m; Weight: 0 kg; Width: 1.27 m
Type - Elettrico - Commenti sul wattaggio: 1; Control Gear: Electronic ballast; Lampada: 1 x LED; Protection Class: Protection class I; Protection Degree: IP65; Standby Power: 0 W; System Power: 56 W
Type - Elettrico - Illuminazione - Luminous efficacy: 133.45 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 46 76 93 94 100; Color Rendering: 82; Color Temperature: 4000 K; Lamp count: 1; Lamp Light Flux: 7473 lm; Lamp Power: 24 W; Lifetime: 50000 h
