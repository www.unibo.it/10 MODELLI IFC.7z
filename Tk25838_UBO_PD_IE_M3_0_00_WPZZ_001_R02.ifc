Properties of the parts of a building model (IFC4), part 4 of 23

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofase (442)
Name (Alimentazione monofase:EFX_I_Alim.NeMonofase:...) | In | Contrassegno | Distanza_simbolo (m) | Nome dispositivo | Livello = Livello abaco | Offset da host (m) | Quota altimetrica da livello (m) | Host
10302285 | L00 - Piano Terra Piazza ELETTRICO | 4620 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10302432 | L00 - Piano Terra Piazza ELETTRICO | 4621 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10302490 | L00 - Piano Terra Piazza ELETTRICO | 4622 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10302519 | L00 - Piano Terra Piazza ELETTRICO | 4623 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10302766 | L00 - Piano Terra Piazza ELETTRICO | 4624 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10302800 | L00 - Piano Terra Piazza ELETTRICO | 4625 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10303115 | L00 - Piano Terra Piazza ELETTRICO | 4626 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10303635 | L00 - Piano Terra Piazza ELETTRICO | 4629 | 0.519614 | Alim.ne boiler | Livello: L01 - Piano Primo ELETTRICO | 0.559942 | 3.60994 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10303687 | L00 - Piano Terra Piazza ELETTRICO | 4630 | 0.5 | Alim.ne boiler | Livello: L01 - Piano Primo ELETTRICO | -1.74682 | 3.30109 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10303953 | L00 - Piano Terra Piazza ELETTRICO | 4633 | 0.5 | Alim.ne VRV | Livello: L01 - Piano Primo ELETTRICO | 46.7969 | 3.97019 | <non associato>
10304083 | L00 - Piano Terra Piazza ELETTRICO | 4634 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10304103 | L00 - Piano Terra Piazza ELETTRICO | 4635 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10304234 | L00 - Piano Terra Piazza ELETTRICO | 4636 | 0.5 | Alim.ne boiler | Livello: L01 - Piano Primo ELETTRICO | -2.28308 | 3.30109 | <non associato>
10304266 | L00 - Piano Terra Piazza ELETTRICO | 4637 | 0.5 | Alim.ne boiler | Livello: L01 - Piano Primo ELETTRICO | -0.488487 | 3.30109 | <non associato>
10304974 | L00 - Piano Terra Piazza ELETTRICO | 4642 | 0.5 | Alim.ne VRV | Livello: L01 - Piano Primo ELETTRICO | 0 | 4.20219 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
10305337 | L00 - Piano Terra Piazza ELETTRICO | 4646 | 0.5 | Alim.ne VRV | Livello: L01 - Piano Primo ELETTRICO | 13.1154 | 4.20219 | <non associato>
10307138 | L02 - Piano Secondo ELETTRICO | 4647 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10307157 | L02 - Piano Secondo ELETTRICO | 4648 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10307344 | L02 - Piano Secondo ELETTRICO | 4649 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10307470 | L02 - Piano Secondo ELETTRICO | 4650 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10307553 | L02 - Piano Secondo ELETTRICO | 4651 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10307567 | L02 - Piano Secondo ELETTRICO | 4652 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10307910 | L02 - Piano Secondo ELETTRICO | 4655 | 0.5 | Alim.ne boiler | Livello: L02 - Piano Secondo ELETTRICO | 0.248529 | 3.15193 | Modello di Revit collegato : P2020-34 Meccanico 2022.09.08.rvt
10307955 | L02 - Piano Secondo ELETTRICO | 4656 | 0.5 | Alim.ne boiler | Livello: L02 - Piano Secondo ELETTRICO | 0.991479 | 3.15193 | <non associato>
10308168 | L02 - Piano Secondo ELETTRICO | 4657 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10308192 | L02 - Piano Secondo ELETTRICO | 4658 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0.0959601 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10308248 | L02 - Piano Secondo ELETTRICO | 4659 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10308445 | L02 - Piano Secondo ELETTRICO | 4660 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10308612 | L02 - Piano Secondo ELETTRICO | 4661 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10308752 | L02 - Piano Secondo ELETTRICO | 4662 | 0.5 | Alim.ne asciugamani | Livello: L02 - Piano Secondo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10308968 | L02 - Piano Secondo ELETTRICO | 4665 | 0.5 | Alim.ne boiler | Livello: L02 - Piano Secondo ELETTRICO | 3.13709 | 3.21109 | <non associato>
10309011 | L02 - Piano Secondo ELETTRICO | 4666 | 0.5 | Alim.ne boiler | Livello: L02 - Piano Secondo ELETTRICO | 0.888888 | 3.21109 | <non associato>
10309858 | L00 - Piano Terra Piazza ELETTRICO | 4670 | 0.5 | Alim.ne schermo motorizzato | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10312791 | B01 - Piano Interrato ELETTRICO | 4690 | 0.5 | Alim.ne asciugamani | Livello: B01 - Piano Interrato ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10312822 | B01 - Piano Interrato ELETTRICO | 4691 | 0.5 | Alim.ne asciugamani | Livello: B01 - Piano Interrato ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10313098 | B01 - Piano Interrato ELETTRICO | 4692 | 0.5 | Alim.ne asciugamani | Livello: B01 - Piano Interrato ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10313395 | B01 - Piano Interrato ELETTRICO | 4693 | 0.5 | Alim.ne asciugamani | Livello: B01 - Piano Interrato ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10313505 | B01 - Piano Interrato ELETTRICO | 4694 | 0.5 | Alim.ne asciugamani | Livello: B01 - Piano Interrato ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10313690 | B01 - Piano Interrato ELETTRICO | 4695 | 0.5 | Alim.ne asciugamani | Livello: B01 - Piano Interrato ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10319826 | L00 - Piano Terra Piazza ELETTRICO | 4709 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10319870 | L00 - Piano Terra Piazza ELETTRICO | 4710 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10319983 | L00 - Piano Terra Piazza ELETTRICO | 4711 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10319999 | L00 - Piano Terra Piazza ELETTRICO | 4712 | 0.5 | Alim.ne asciugamani | Livello: L01 - Piano Primo ELETTRICO | 0 | 0.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10320317 | L00 - Piano Terra Piazza ELETTRICO | 4713 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10320415 | L00 - Piano Terra Piazza ELETTRICO | 4714 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10320438 | L00 - Piano Terra Piazza ELETTRICO | 4715 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10320457 | L00 - Piano Terra Piazza ELETTRICO | 4716 | 0.5 | Alim.ne asciugamani | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10324363 | L00 - Piano Terra Piazza ELETTRICO | 4720 | 0.5 | Alim.ne boiler | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.9 | 3.51862 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10326524 | B01 - Piano Interrato ELETTRICO | 4721 | 0.5 | Fila 1 DX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.08 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326586 | B01 - Piano Interrato ELETTRICO | 4722 | 0.5 | Fila 2 DX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.2 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326632 | B01 - Piano Interrato ELETTRICO | 4723 | 0.5 | Fila 3 DX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.42 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326685 | B01 - Piano Interrato ELETTRICO | 4724 | 0.5 | Fila 4 DX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.76 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326725 | B01 - Piano Interrato ELETTRICO | 4725 | 0.5 | Fila 5 DX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 2.02 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326766 | B01 - Piano Interrato ELETTRICO | 4726 | 0.5 | Fila 6 DX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 2.3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326803 | L00 - Piano Terra Piazza ELETTRICO | 4727 | 0.5 | Fila 7 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326843 | L00 - Piano Terra Piazza ELETTRICO | 4728 | 0.5 | Fila 8 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326896 | L00 - Piano Terra Piazza ELETTRICO | 4729 | 0.5 | Fila 9 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10326941 | L00 - Piano Terra Piazza ELETTRICO | 4730 | 0.5 | Fila 10 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327001 | L00 - Piano Terra Piazza ELETTRICO | 4731 | 0.5 | Fila 11 DX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0.18 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327070 | B01 - Piano Interrato ELETTRICO | 4732 | 0.5 | Fila 1 SX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.06 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327112 | B01 - Piano Interrato ELETTRICO | 4733 | 0.5 | Fila 2 SX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.22 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327152 | B01 - Piano Interrato ELETTRICO | 4734 | 0.5 | Fila 3 SX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.38 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327203 | B01 - Piano Interrato ELETTRICO | 4735 | 0.5 | Fila 4 SX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327265 | B01 - Piano Interrato ELETTRICO | 4736 | 0.5 | Fila 5 SX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 1.94 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327311 | B01 - Piano Interrato ELETTRICO | 4737 | 0.5 | Fila 6 SX | Livello: B01 - Piano Interrato ELETTRICO | 0 | 2.26 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327348 | L00 - Piano Terra Piazza ELETTRICO | 4738 | 0.5 | Fila 7 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327389 | L00 - Piano Terra Piazza ELETTRICO | 4739 | 0.5 | Fila 8 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327438 | L00 - Piano Terra Piazza ELETTRICO | 4740 | 0.5 | Fila 9 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327468 | L00 - Piano Terra Piazza ELETTRICO | 4741 | 0.5 | Fila 10 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10327506 | L00 - Piano Terra Piazza ELETTRICO | 4742 | 0.5 | Fila 11 SX | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 0.22 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10350266 | L00 - Piano Terra Piazza ELETTRICO | 4459 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10350448 | L00 - Piano Terra Piazza ELETTRICO | 4463 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10350467 | L00 - Piano Terra Piazza ELETTRICO | 4500 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10350608 | L00 - Piano Terra Piazza ELETTRICO | 4501 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10350764 | L00 - Piano Terra Piazza ELETTRICO | 4503 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10350984 | L00 - Piano Terra Piazza ELETTRICO | 4504 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10351156 | L00 - Piano Terra Piazza ELETTRICO | 4509 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10351325 | L00 - Piano Terra Piazza ELETTRICO | 4523 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10351507 | L00 - Piano Terra Piazza ELETTRICO | 4524 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10351622 | L00 - Piano Terra Piazza ELETTRICO | 4525 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10351918 | L00 - Piano Terra Piazza ELETTRICO | 4560 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10352163 | L00 - Piano Terra Piazza ELETTRICO | 4561 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10352444 | L00 - Piano Terra Piazza ELETTRICO | 4562 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10352733 | L00 - Piano Terra Piazza ELETTRICO | 4570 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10353437 | L00 - Piano Terra Piazza ELETTRICO | 4571 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10353451 | L00 - Piano Terra Piazza ELETTRICO | 4574 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10353753 | L00 - Piano Terra Piazza ELETTRICO | 4576 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10354167 | L00 - Piano Terra Piazza ELETTRICO | 4672 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10354198 | L00 - Piano Terra Piazza ELETTRICO | 4686 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10354635 | L00 - Piano Terra Piazza ELETTRICO | 4700 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10354899 | L00 - Piano Terra Piazza ELETTRICO | 4743 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10355207 | L00 - Piano Terra Piazza ELETTRICO | 4744 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10355533 | L00 - Piano Terra Piazza ELETTRICO | 4745 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10355803 | L00 - Piano Terra Piazza ELETTRICO | 4746 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10356097 | L00 - Piano Terra Piazza ELETTRICO | 4747 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10356470 | L00 - Piano Terra Piazza ELETTRICO | 4748 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10356755 | L00 - Piano Terra Piazza ELETTRICO | 4749 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10357142 | L00 - Piano Terra Piazza ELETTRICO | 4750 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10357479 | L00 - Piano Terra Piazza ELETTRICO | 4751 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10358348 | L00 - Piano Terra Piazza ELETTRICO | 4752 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10358803 | L00 - Piano Terra Piazza ELETTRICO | 4753 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10359301 | L00 - Piano Terra Piazza ELETTRICO | 4754 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10359603 | L00 - Piano Terra Piazza ELETTRICO | 4755 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10360041 | L00 - Piano Terra Piazza ELETTRICO | 4756 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10360909 | L00 - Piano Terra Piazza ELETTRICO | 4757 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10361096 | L00 - Piano Terra Piazza ELETTRICO | 4758 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10361208 | L00 - Piano Terra Piazza ELETTRICO | 4759 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10361408 | L00 - Piano Terra Piazza ELETTRICO | 4760 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10361521 | L00 - Piano Terra Piazza ELETTRICO | 4761 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10361659 | L00 - Piano Terra Piazza ELETTRICO | 4762 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10361803 | L00 - Piano Terra Piazza ELETTRICO | 4763 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10361954 | L00 - Piano Terra Piazza ELETTRICO | 4764 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10362104 | L00 - Piano Terra Piazza ELETTRICO | 4765 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10362234 | L00 - Piano Terra Piazza ELETTRICO | 4766 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10362588 | L02 - Piano Secondo ELETTRICO | 4767 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10362637 | L02 - Piano Secondo ELETTRICO | 4768 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10362810 | L02 - Piano Secondo ELETTRICO | 4769 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10363270 | L02 - Piano Secondo ELETTRICO | 4770 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10363423 | L02 - Piano Secondo ELETTRICO | 4771 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10363779 | L02 - Piano Secondo ELETTRICO | 4772 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10364040 | L02 - Piano Secondo ELETTRICO | 4773 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10364282 | L02 - Piano Secondo ELETTRICO | 4774 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10364620 | L02 - Piano Secondo ELETTRICO | 4775 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10364836 | L02 - Piano Secondo ELETTRICO | 4776 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10365223 | L02 - Piano Secondo ELETTRICO | 4777 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10365750 | L02 - Piano Secondo ELETTRICO | 4778 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10365869 | L02 - Piano Secondo ELETTRICO | 4779 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10366226 | L02 - Piano Secondo ELETTRICO | 4780 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10366765 | L02 - Piano Secondo ELETTRICO | 4781 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10366804 | L02 - Piano Secondo ELETTRICO | 4782 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10367140 | L02 - Piano Secondo ELETTRICO | 4783 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10367556 | L02 - Piano Secondo ELETTRICO | 4784 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10368008 | L02 - Piano Secondo ELETTRICO | 4785 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10368672 | L02 - Piano Secondo ELETTRICO | 4786 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10369010 | L02 - Piano Secondo ELETTRICO | 4787 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10369300 | L02 - Piano Secondo ELETTRICO | 4788 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10369670 | L02 - Piano Secondo ELETTRICO | 4789 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10370063 | L02 - Piano Secondo ELETTRICO | 4790 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10370328 | L02 - Piano Secondo ELETTRICO | 4791 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10370614 | L02 - Piano Secondo ELETTRICO | 4792 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10370852 | L02 - Piano Secondo ELETTRICO | 4793 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10371155 | L02 - Piano Secondo ELETTRICO | 4794 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10371456 | L02 - Piano Secondo ELETTRICO | 4795 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10372357 | L00 - Piano Terra Piazza ELETTRICO | 4796 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10372675 | L00 - Piano Terra Piazza ELETTRICO | 4797 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10372704 | L00 - Piano Terra Piazza ELETTRICO | 4798 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10372852 | L00 - Piano Terra Piazza ELETTRICO | 4799 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10373412 | L00 - Piano Terra Piazza ELETTRICO | 4800 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10373534 | L00 - Piano Terra Piazza ELETTRICO | 4801 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | -0.289865 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10373708 | L00 - Piano Terra Piazza ELETTRICO | 4802 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10373857 | L00 - Piano Terra Piazza ELETTRICO | 4803 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10374007 | L00 - Piano Terra Piazza ELETTRICO | 4804 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10375537 | L00 - Piano Terra Piazza ELETTRICO | 4805 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10375578 | L00 - Piano Terra Piazza ELETTRICO | 4806 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10375780 | L00 - Piano Terra Piazza ELETTRICO | 4807 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10375928 | L00 - Piano Terra Piazza ELETTRICO | 4808 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10376871 | L00 - Piano Terra Piazza ELETTRICO | 4809 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10377066 | L00 - Piano Terra Piazza ELETTRICO | 4810 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10377243 | L00 - Piano Terra Piazza ELETTRICO | 4811 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10377711 | L00 - Piano Terra Piazza ELETTRICO | 4812 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10378031 | L00 - Piano Terra Piazza ELETTRICO | 4813 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10378289 | L00 - Piano Terra Piazza ELETTRICO | 4814 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.9 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424536 | L02 - Piano Secondo ELETTRICO | 4815 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.74756 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424538 | L02 - Piano Secondo ELETTRICO | 4816 | 0.987474 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.74505 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424539 | L02 - Piano Secondo ELETTRICO | 4882 | 0.169082 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7531 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424541 | L02 - Piano Secondo ELETTRICO | 4883 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.75499 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424542 | L02 - Piano Secondo ELETTRICO | 4884 | 0.526903 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424543 | L02 - Piano Secondo ELETTRICO | 4885 | 0.546309 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424544 | L02 - Piano Secondo ELETTRICO | 4886 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424545 | L02 - Piano Secondo ELETTRICO | 4887 | 0.5 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424546 | L00 - Piano Terra Piazza ELETTRICO | 4888 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424549 | L00 - Piano Terra Piazza ELETTRICO | 4889 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424550 | L00 - Piano Terra Piazza ELETTRICO | 4890 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10424551 | L00 - Piano Terra Piazza ELETTRICO | 4891 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429120 | L02 - Piano Secondo ELETTRICO | 4892 | 0.495388 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429121 | L02 - Piano Secondo ELETTRICO | 4893 | 0.467477 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.72656 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429122 | L02 - Piano Secondo ELETTRICO | 4894 | 0.481686 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429123 | L02 - Piano Secondo ELETTRICO | 4895 | 0.523036 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429124 | L02 - Piano Secondo ELETTRICO | 4896 | 0.480985 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429125 | L02 - Piano Secondo ELETTRICO | 4897 | 0.453559 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429126 | L02 - Piano Secondo ELETTRICO | 4898 | 0.495726 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429127 | L02 - Piano Secondo ELETTRICO | 4899 | 0.502036 | Alim.ne Tende | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.72158 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429140 | L00 - Piano Terra Piazza ELETTRICO | 4900 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429141 | L00 - Piano Terra Piazza ELETTRICO | 4901 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429142 | L00 - Piano Terra Piazza ELETTRICO | 4902 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429143 | L00 - Piano Terra Piazza ELETTRICO | 4903 | 0.5 | Alim.ne Tende | Livello: L01 - Piano Primo ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429144 | L00 - Piano Terra Piazza ELETTRICO | 4904 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0452604 | 3.95474 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429145 | L00 - Piano Terra Piazza ELETTRICO | 4905 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429146 | L00 - Piano Terra Piazza ELETTRICO | 4906 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429147 | L00 - Piano Terra Piazza ELETTRICO | 4907 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429148 | L00 - Piano Terra Piazza ELETTRICO | 4908 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0150868 | 3.98491 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429149 | L00 - Piano Terra Piazza ELETTRICO | 4909 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 4 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429150 | L00 - Piano Terra Piazza ELETTRICO | 4910 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0716142 | 3.92839 | <non associato>
10429152 | L00 - Piano Terra Piazza ELETTRICO | 4911 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0716142 | 3.92839 | <non associato>
10429153 | L00 - Piano Terra Piazza ELETTRICO | 4912 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0716142 | 3.92839 | <non associato>
10429154 | L00 - Piano Terra Piazza ELETTRICO | 4913 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0716142 | 3.92839 | <non associato>
10429155 | L00 - Piano Terra Piazza ELETTRICO | 4914 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0716142 | 3.92839 | <non associato>
10429156 | L00 - Piano Terra Piazza ELETTRICO | 4915 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.0716142 | 3.92839 | <non associato>
10429159 | L00 - Piano Terra Piazza ELETTRICO | 4916 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.1 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429160 | L00 - Piano Terra Piazza ELETTRICO | 4917 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.1 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429161 | L00 - Piano Terra Piazza ELETTRICO | 4918 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.1 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429162 | L00 - Piano Terra Piazza ELETTRICO | 4919 | 0.5 | Alim.ne Tende | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.1 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429267 | L00 - Piano Terra Piazza ELETTRICO | 4920 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429272 | L00 - Piano Terra Piazza ELETTRICO | 4921 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 3.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429273 | L00 - Piano Terra Piazza ELETTRICO | 4922 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429274 | L00 - Piano Terra Piazza ELETTRICO | 4923 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429275 | L00 - Piano Terra Piazza ELETTRICO | 4924 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429276 | L00 - Piano Terra Piazza ELETTRICO | 4925 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.7 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429277 | L00 - Piano Terra Piazza ELETTRICO | 4927 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429278 | L00 - Piano Terra Piazza ELETTRICO | 4928 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429279 | L00 - Piano Terra Piazza ELETTRICO | 4929 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 3 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429288 | L00 - Piano Terra Piazza ELETTRICO | 4930 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429314 | L00 - Piano Terra Piazza ELETTRICO | 4931 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429323 | L00 - Piano Terra Piazza ELETTRICO | 4932 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429324 | L00 - Piano Terra Piazza ELETTRICO | 4933 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429326 | L00 - Piano Terra Piazza ELETTRICO | 4934 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429327 | L00 - Piano Terra Piazza ELETTRICO | 4935 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429328 | L00 - Piano Terra Piazza ELETTRICO | 4936 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429330 | L00 - Piano Terra Piazza ELETTRICO | 4937 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429332 | L00 - Piano Terra Piazza ELETTRICO | 4938 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429340 | L00 - Piano Terra Piazza ELETTRICO | 4939 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429342 | L02 - Piano Secondo ELETTRICO | 4940 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429344 | L02 - Piano Secondo ELETTRICO | 4941 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429358 | L02 - Piano Secondo ELETTRICO | 4943 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429359 | L02 - Piano Secondo ELETTRICO | 4944 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429361 | L02 - Piano Secondo ELETTRICO | 4945 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429363 | L02 - Piano Secondo ELETTRICO | 4946 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429365 | L00 - Piano Terra Piazza ELETTRICO | 4947 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429367 | L00 - Piano Terra Piazza ELETTRICO | 4948 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429368 | L00 - Piano Terra Piazza ELETTRICO | 4949 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429372 | L00 - Piano Terra Piazza ELETTRICO | 4950 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429374 | L00 - Piano Terra Piazza ELETTRICO | 4951 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429376 | L00 - Piano Terra Piazza ELETTRICO | 4952 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429378 | L00 - Piano Terra Piazza ELETTRICO | 4953 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429380 | L00 - Piano Terra Piazza ELETTRICO | 4954 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429385 | B01 - Piano Interrato ELETTRICO | 4955 | 0.5 | Alim.ne sonda ambiente | Livello: B01 - Piano Interrato ELETTRICO | -0.0885 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429387 | B01 - Piano Interrato ELETTRICO | 4956 | 0.5 | Alim.ne sonda ambiente | Livello: B01 - Piano Interrato ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429389 | B01 - Piano Interrato ELETTRICO | 4957 | 0.5 | Alim.ne sonda ambiente | Livello: B01 - Piano Interrato ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429390 | L00 - Piano Terra Piazza ELETTRICO | 4958 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429392 | L00 - Piano Terra Piazza ELETTRICO | 4959 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429394 | L00 - Piano Terra Piazza ELETTRICO | 4960 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10429395 | L00 - Piano Terra Piazza ELETTRICO | 4961 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt
10429397 | L00 - Piano Terra Piazza ELETTRICO | 4962 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429398 | L00 - Piano Terra Piazza ELETTRICO | 4963 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429431 | L00 - Piano Terra Piazza ELETTRICO | 4964 | 0.5 | Alim.ne sonda ambiente | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429432 | L00 - Piano Terra Piazza ELETTRICO | 4965 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429433 | L00 - Piano Terra Piazza ELETTRICO | 4966 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429434 | L00 - Piano Terra Piazza ELETTRICO | 4967 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429435 | L00 - Piano Terra Piazza ELETTRICO | 4968 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10429664 | L00 - Piano Terra Piazza ELETTRICO | 4969 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10430208 | L00 - Piano Terra Piazza ELETTRICO | 4970 | 0.5 | Alim.ne sonda ambiente | Livello: L01 - Piano Primo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10430275 | L02 - Piano Secondo ELETTRICO | 4972 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10430402 | L02 - Piano Secondo ELETTRICO | 4973 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10430929 | L02 - Piano Secondo ELETTRICO | 4974 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10431088 | L02 - Piano Secondo ELETTRICO | 4975 | 0.5 | Alim.ne sonda ambiente | Livello: L02 - Piano Secondo ELETTRICO | 0 | 2.6 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofase CDS, Alimentazione monofase:EFX_I_Alim.NeMonofase CDS:10696276
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: Alim. mono.; Nome famiglia: Alimentazione monofase
Type - Dati identità - Contrassegno tipo: 1; Nome del tipo: EFX_I_Alim.NeMonofase CDS; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Alim.NeMonofase CDS
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Alim.NeMonofase CDS
Material: Placca, Metallo
Altro - Famiglia: Alimentazione monofase: EFX_I_Alim.NeMonofase CDS; Famiglia e tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase CDS; ID tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase CDS; Tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase CDS
Dati identità - Contrassegno: 5069
Dimensioni - Area: 0.0113601 m2; Distanza_simbolo: 0.5 m; Volume: 0.0000363445 m3
Elettrico - Load: 100 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-100 W
Fasi - Fase di creazione: Nuova costruzione
Generale - Nome dispositivo: Alim.ne CDS
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 1.18634 m

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofase CIE, Alimentazione monofase:EFX_I_Alim.NeMonofase CIE:10696185
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: Alim. mono.; Nome famiglia: Alimentazione monofase
Type - Dati identità - Contrassegno tipo: 1; Nome del tipo: EFX_I_Alim.NeMonofase CIE; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Alim.NeMonofase CIE
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Alim.NeMonofase CIE
Material: Placca, Metallo
Altro - Famiglia: Alimentazione monofase: EFX_I_Alim.NeMonofase CIE; Famiglia e tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase CIE; ID tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase CIE; Tipo: Alimentazione monofase: EFX_I_Alim.NeMonofase CIE
Dati identità - Contrassegno: 5068
Dimensioni - Area: 0.0113601 m2; Distanza_simbolo: 0.5 m; Volume: 0.0000363445 m3
Elettrico - Load: 100 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-100 W
Fasi - Fase di creazione: Nuova costruzione
Generale - Nome dispositivo: Alim.ne CIE
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO; Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 1.18634 m

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofaseIp55 (2)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Alimentazione monofase; Tipologia presa: Alim. mono. IP55
Type - Dati identità - Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_Alim.NeMonofaseIp55; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Alim.NeMonofaseIp55
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Alim.NeMonofaseIp55
Material: Placca, Metallo
Altro - Famiglia: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55; Famiglia e tipo: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55; ID tipo: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55; Tipo: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55
Dimensioni - Area: 0.025492 m2; Distanza_simbolo: 0.5 m; Volume: 0.000677614 m3
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO
Name (Alimentazione monofase:EFX_I_Alim.NeMonofaseIp55:...) | Contrassegno | Load (W) | Dati elettrici | Nome dispositivo | Offset da host (m) | Host | Quota altimetrica da livello (m)
9891382 | 4539 | 180 | 230 V/1-180 W | Alim.ne ventil | 0 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10289424 | 4547 | 100 | 230 V/1-100 W | Alim.ne cancello automatico | 0.10019 | <non associato> | 2.80181

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofaseIp55-CRF, Alimentazione monofase:EFX_I_Alim.NeMonofaseIp55-CRF:10696015
In: B01 - Piano Interrato ELETTRICO
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: Alim. mono. IP55; Nome famiglia: Alimentazione monofase
Type - Dati identità - Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_Alim.NeMonofaseIp55-CRF; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Alim.NeMonofaseIp55-CRF
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Alim.NeMonofaseIp55-CRF
Material: Placca, Metallo
Altro - Famiglia: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55-CRF; Famiglia e tipo: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55-CRF; ID tipo: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55-CRF; Tipo: Alimentazione monofase: EFX_I_Alim.NeMonofaseIp55-CRF
Dati identità - Contrassegno: 5067
Dimensioni - Area: 0.025492 m2; Distanza_simbolo: 0.5 m; Volume: 0.000677614 m3
Elettrico - Load: 100 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-100 W
Fasi - Fase di creazione: Nuova costruzione
Generale - Nome dispositivo: Alim.ne CRF
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 1.12889 m

# IfcBuildingElementProxy: Alimentazione monofase:EFX_I_Alim.NeMonofase_Soff (112)
Type - Material: Placca
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: Alim. mono.; Nome famiglia: Alimentazione monofase
Type - Dati identità - Commenti sul tipo: Soff; Nome del tipo: EFX_I_Alim.NeMonofase_Soff; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 0.3 m
