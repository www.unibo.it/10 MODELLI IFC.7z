Properties of the parts of a building model (IFC4), part 8 of 23

# IfcBuildingElementProxy: Prese:EFX_I_Unel+BipassoIp55 (10)
Name (Prese:EFX_I_Unel+BipassoIp55:...) | Contrassegno | Distanza_simbolo (m) | Host | Quota altimetrica da livello (m)
9892894 | 4544 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.1 | Dati identità - Commenti: Aula magna
10290081 | 4548 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10290102 | 4549 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10290342 | 4550 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2
10291392 | 4551 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10291576 | 4552 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.2
10292201 | 4553 | 0.5 | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.2

# IfcBuildingElementProxy: Prese:EFX_I_Unel+BipassoUps (115)
Type - Material: Frutto
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Prese; Tipologia presa: 05 - Unel + Bipasso
Type - Dati identità - Commenti sul tipo: ups; Label: GFCI; Nome del tipo: EFX_I_Unel+BipassoUps; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 120 V
Type - Grafica - Simbolo: 05
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_Unel+BipassoUps
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_Unel+BipassoUps
Material: Frutto, Placca
Altro - Famiglia: Prese: EFX_I_Unel+BipassoUps; Famiglia e tipo: Prese: EFX_I_Unel+BipassoUps; ID tipo: Prese: EFX_I_Unel+BipassoUps; Tipo: Prese: EFX_I_Unel+BipassoUps
Dimensioni - Area: 0.0233356 m2; Volume: 0.00012899 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-200 W
Fasi - Fase di creazione: Nuova costruzione
Name (Prese:EFX_I_Unel+BipassoUps:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
8715617 | L00 - Piano Terra Piazza ELETTRICO | 3646 | 0.659145 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8715907 | L00 - Piano Terra Piazza ELETTRICO | 3648 | 0.69743 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8716210 | L00 - Piano Terra Piazza ELETTRICO | 3651 | 0.460796 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8716423 | L00 - Piano Terra Piazza ELETTRICO | 3654 | 0.3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.2848
8717442 | L00 - Piano Terra Piazza ELETTRICO | 3656 | 0.706154 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8717572 | L00 - Piano Terra Piazza ELETTRICO | 3658 | 0.746521 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8717922 | L00 - Piano Terra Piazza ELETTRICO | 3660 | 0.0553828 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8718066 | L00 - Piano Terra Piazza ELETTRICO | 3662 | 0.864488 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8719034 | L00 - Piano Terra Piazza ELETTRICO | 3664 | 0.548579 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8719132 | L00 - Piano Terra Piazza ELETTRICO | 3666 | 1.02672 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8719431 | L00 - Piano Terra Piazza ELETTRICO | 3668 | 1.01454 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8719497 | L00 - Piano Terra Piazza ELETTRICO | 3670 | 0.524955 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8720975 | L00 - Piano Terra Piazza ELETTRICO | 3674 | 0.724069 | Livello: L00 - Piano Terra Piazza ELETTRICO | -3.46957e-09 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8721100 | L00 - Piano Terra Piazza ELETTRICO | 3676 | 0.727195 | Livello: L00 - Piano Terra Piazza ELETTRICO | -3.61363e-09 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8721256 | L00 - Piano Terra Piazza ELETTRICO | 3678 | 0.684206 | Livello: L00 - Piano Terra Piazza ELETTRICO | -3.47153e-09 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8723326 | L00 - Piano Terra Piazza ELETTRICO | 3683 | 0.3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8723433 | L00 - Piano Terra Piazza ELETTRICO | 3685 | 0.3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8723516 | L00 - Piano Terra Piazza ELETTRICO | 3687 | 0.3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8828506 | L00 - Piano Terra Piazza ELETTRICO | 3722 | 0.3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8828654 | L00 - Piano Terra Piazza ELETTRICO | 3724 | 0.3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8828836 | L00 - Piano Terra Piazza ELETTRICO | 3726 | 0.3 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8966752 | L00 - Piano Terra Piazza ELETTRICO | 3817 | 0.299103 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8967693 | L00 - Piano Terra Piazza ELETTRICO | 3820 | 0.326773 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8968605 | L00 - Piano Terra Piazza ELETTRICO | 3822 | 0.171126 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8968762 | L00 - Piano Terra Piazza ELETTRICO | 3824 | 0.040965 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8969106 | L00 - Piano Terra Piazza ELETTRICO | 3826 | 0.122919 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8969209 | L00 - Piano Terra Piazza ELETTRICO | 3827 | 0.722783 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8970729 | L00 - Piano Terra Piazza ELETTRICO | 3834 | 0.322075 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8970858 | L00 - Piano Terra Piazza ELETTRICO | 3836 | 0.32499 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8971113 | L00 - Piano Terra Piazza ELETTRICO | 3838 | 0.30368 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8971315 | L00 - Piano Terra Piazza ELETTRICO | 3840 | 0.296166 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8971952 | L00 - Piano Terra Piazza ELETTRICO | 3842 | 0.298094 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8972200 | L00 - Piano Terra Piazza ELETTRICO | 3844 | 0.287524 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8972529 | L00 - Piano Terra Piazza ELETTRICO | 3846 | 0.249308 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8972880 | L00 - Piano Terra Piazza ELETTRICO | 3847 | 0.345785 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8973206 | L00 - Piano Terra Piazza ELETTRICO | 3850 | 0.307004 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8973532 | L00 - Piano Terra Piazza ELETTRICO | 3851 | 0.312577 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8973830 | L00 - Piano Terra Piazza ELETTRICO | 3854 | 0.289423 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8974019 | L00 - Piano Terra Piazza ELETTRICO | 3856 | 0.29829 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8974871 | L00 - Piano Terra Piazza ELETTRICO | 3858 | 0.296745 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8975136 | L00 - Piano Terra Piazza ELETTRICO | 3860 | 0.315171 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8975584 | L00 - Piano Terra Piazza ELETTRICO | 3862 | 0.295264 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8976354 | L00 - Piano Terra Piazza ELETTRICO | 3866 | 0.291348 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8976710 | L00 - Piano Terra Piazza ELETTRICO | 3867 | 0.403368 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8976810 | L00 - Piano Terra Piazza ELETTRICO | 3870 | 0.330111 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8978950 | L00 - Piano Terra Piazza ELETTRICO | 3883 | 0.34325 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8979054 | L00 - Piano Terra Piazza ELETTRICO | 3885 | 0.332258 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8985837 | L02 - Piano Secondo ELETTRICO | 3950 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986012 | L02 - Piano Secondo ELETTRICO | 3952 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986061 | L02 - Piano Secondo ELETTRICO | 3954 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986186 | L02 - Piano Secondo ELETTRICO | 3955 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986387 | L02 - Piano Secondo ELETTRICO | 3958 | 0.293097 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986601 | L02 - Piano Secondo ELETTRICO | 3960 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986663 | L02 - Piano Secondo ELETTRICO | 3962 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986747 | L02 - Piano Secondo ELETTRICO | 3964 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986815 | L02 - Piano Secondo ELETTRICO | 3966 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986911 | L02 - Piano Secondo ELETTRICO | 3968 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987064 | L02 - Piano Secondo ELETTRICO | 3970 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987109 | L02 - Piano Secondo ELETTRICO | 3972 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987176 | L02 - Piano Secondo ELETTRICO | 3974 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987240 | L02 - Piano Secondo ELETTRICO | 3975 | 0.7 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987525 | L02 - Piano Secondo ELETTRICO | 3978 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987613 | L02 - Piano Secondo ELETTRICO | 3980 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987673 | L02 - Piano Secondo ELETTRICO | 3982 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987783 | L02 - Piano Secondo ELETTRICO | 3984 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987846 | L02 - Piano Secondo ELETTRICO | 3986 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987912 | L02 - Piano Secondo ELETTRICO | 3988 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988015 | L02 - Piano Secondo ELETTRICO | 3990 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988075 | L02 - Piano Secondo ELETTRICO | 3992 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988170 | L02 - Piano Secondo ELETTRICO | 3995 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988242 | L02 - Piano Secondo ELETTRICO | 3997 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988394 | L02 - Piano Secondo ELETTRICO | 3999 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988568 | L02 - Piano Secondo ELETTRICO | 4001 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988631 | L02 - Piano Secondo ELETTRICO | 4003 | 0.0843323 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988711 | L02 - Piano Secondo ELETTRICO | 4005 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988831 | L02 - Piano Secondo ELETTRICO | 4007 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988926 | L02 - Piano Secondo ELETTRICO | 4009 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988998 | L02 - Piano Secondo ELETTRICO | 4011 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989064 | L02 - Piano Secondo ELETTRICO | 4013 | 0.331021 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989142 | L02 - Piano Secondo ELETTRICO | 4015 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989199 | L02 - Piano Secondo ELETTRICO | 4017 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989286 | L02 - Piano Secondo ELETTRICO | 4019 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989368 | L02 - Piano Secondo ELETTRICO | 4021 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989435 | L02 - Piano Secondo ELETTRICO | 4023 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989534 | L02 - Piano Secondo ELETTRICO | 4025 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989606 | L02 - Piano Secondo ELETTRICO | 4027 | 0 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989617 | L02 - Piano Secondo ELETTRICO | 4028 | 0.6 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989765 | L02 - Piano Secondo ELETTRICO | 4031 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989834 | L02 - Piano Secondo ELETTRICO | 4033 | 0.6 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989862 | L02 - Piano Secondo ELETTRICO | 4035 | 0 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989957 | L02 - Piano Secondo ELETTRICO | 4037 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990032 | L02 - Piano Secondo ELETTRICO | 4039 | 0.6 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990054 | L02 - Piano Secondo ELETTRICO | 4041 | 0 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990179 | L02 - Piano Secondo ELETTRICO | 4043 | 0.6 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990222 | L02 - Piano Secondo ELETTRICO | 4045 | 0 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990372 | L02 - Piano Secondo ELETTRICO | 4047 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990529 | L02 - Piano Secondo ELETTRICO | 4049 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990557 | L02 - Piano Secondo ELETTRICO | 4051 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990766 | L02 - Piano Secondo ELETTRICO | 4053 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990864 | L02 - Piano Secondo ELETTRICO | 4055 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990886 | L02 - Piano Secondo ELETTRICO | 4057 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990987 | L02 - Piano Secondo ELETTRICO | 4059 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991032 | L02 - Piano Secondo ELETTRICO | 4061 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991082 | L02 - Piano Secondo ELETTRICO | 4063 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991284 | L02 - Piano Secondo ELETTRICO | 4065 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991330 | L02 - Piano Secondo ELETTRICO | 4067 | 0.3 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8998910 | L02 - Piano Secondo ELETTRICO | 4122 | 0.114113 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8999016 | L02 - Piano Secondo ELETTRICO | 4124 | 0.320417 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8999038 | L02 - Piano Secondo ELETTRICO | 4126 | 0.305395 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8999282 | L02 - Piano Secondo ELETTRICO | 4128 | 0.249418 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8999304 | L02 - Piano Secondo ELETTRICO | 4130 | 0.288223 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
10314034 | L00 - Piano Terra Piazza ELETTRICO | 4696 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10314055 | L00 - Piano Terra Piazza ELETTRICO | 4697 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10314209 | L00 - Piano Terra Piazza ELETTRICO | 4698 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna
10314373 | L00 - Piano Terra Piazza ELETTRICO | 4699 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3 | Dati identità - Commenti: Aula magna

# IfcBuildingElementProxy: Prese:EFX_I_UnelIp55 (3)
In: B01 - Piano Interrato ELETTRICO
Type - Material: Frutto
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Prese; Tipologia presa: 06 - Unel IP55
Type - Dati identità - Commenti sul tipo: 1; Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_UnelIp55; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 120 V
Type - Grafica - Simbolo: 06
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_UnelIp55
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_UnelIp55
Material: Frutto, Placca
Altro - Famiglia: Prese: EFX_I_UnelIp55; Famiglia e tipo: Prese: EFX_I_UnelIp55; ID tipo: Prese: EFX_I_UnelIp55; Tipo: Prese: EFX_I_UnelIp55
Dimensioni - Area: 0.0233356 m2; Distanza_simbolo: 0.5 m; Volume: 0.00012899 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-200 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: B01 - Piano Interrato ELETTRICO; Livello abaco: Livello: B01 - Piano Interrato ELETTRICO; Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 0.3 m
Name (Prese:EFX_I_UnelIp55:...) | Contrassegno
10321813 | 4717
10321884 | 4718
10321896 | 4719

# IfcBuildingElementProxy: Prese:EFX_I_UnelSingola (9)
Type - Material: Frutto
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Prese; Tipologia presa: 04 - Unel singola
Type - Dati identità - Commenti sul tipo: 1; Contrassegno tipo: 1; Label: GFCI; Nome del tipo: EFX_I_UnelSingola; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 120 V
Type - Grafica - Simbolo: 04
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_UnelSingola
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_UnelSingola
Material: Frutto, Placca
Altro - Famiglia: Prese: EFX_I_UnelSingola; Famiglia e tipo: Prese: EFX_I_UnelSingola; ID tipo: Prese: EFX_I_UnelSingola; Tipo: Prese: EFX_I_UnelSingola
Dimensioni - Area: 0.0233356 m2; Distanza_simbolo: 0.5 m; Volume: 0.00012899 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-200 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
Name (Prese:EFX_I_UnelSingola:...) | In | Contrassegno | Livello = Livello abaco | Quota altimetrica da livello (m)
8722021 | L00 - Piano Terra Piazza ELETTRICO | 3679 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.35
8722049 | L00 - Piano Terra Piazza ELETTRICO | 3680 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.35
8722328 | L00 - Piano Terra Piazza ELETTRICO | 3681 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.35
10303238 | L00 - Piano Terra Piazza ELETTRICO | 4627 | Livello: L01 - Piano Primo ELETTRICO | 0.3
10303258 | L00 - Piano Terra Piazza ELETTRICO | 4628 | Livello: L01 - Piano Primo ELETTRICO | 0.3
10307720 | L02 - Piano Secondo ELETTRICO | 4653 | Livello: L02 - Piano Secondo ELETTRICO | 0.3
10307734 | L02 - Piano Secondo ELETTRICO | 4654 | Livello: L02 - Piano Secondo ELETTRICO | 0.3
10308837 | L02 - Piano Secondo ELETTRICO | 4663 | Livello: L02 - Piano Secondo ELETTRICO | 0.3
10308913 | L02 - Piano Secondo ELETTRICO | 4664 | Livello: L02 - Piano Secondo ELETTRICO | 0.3

# IfcBuildingElementProxy: Prese:EFX_I_UnelSingolaSoffitto (42)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Frutto
Type - Altro - Categoria: Apparecchi elettrici; Tipologia presa: 04 - Unel singola; Nome famiglia: Prese
Type - Dati identità - Commenti sul tipo: Soff; Label: GFCI; Nome del tipo: EFX_I_UnelSingolaSoffitto; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 120 V
Type - Grafica - Simbolo: 04
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EFX_I_UnelSingolaSoffitto
Type - Pset_EnvironmentalImpactIndicators - Reference: EFX_I_UnelSingolaSoffitto
Material: Frutto, Placca
Altro - Famiglia: Prese: EFX_I_UnelSingolaSoffitto; Famiglia e tipo: Prese: EFX_I_UnelSingolaSoffitto; ID tipo: Prese: EFX_I_UnelSingolaSoffitto; Tipo: Prese: EFX_I_UnelSingolaSoffitto
Dimensioni - Area: 0.0233356 m2; Distanza_simbolo: 0.5 m; Volume: 0.00012899 m3
Elettrico - Load: 180 W
Elettrico - Circuiti - Dati elettrici: 230 V/1-200 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (Prese:EFX_I_UnelSingolaSoffitto:...) | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
8781628 | 3695 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8781636 | 3696 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8781786 | 3698 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8781794 | 3699 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8781882 | 3702 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8831923 | 3780 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8831935 | 3781 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8831951 | 3783 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8831961 | 3784 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8832039 | 3785 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8982022 | 3895 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8982045 | 3896 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
8982349 | 3900 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8982361 | 3901 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8982369 | 3902 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8982454 | 3903 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8982813 | 3910 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 4
8983452 | 3920 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
8983502 | 3922 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
8983514 | 3923 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
8983596 | 3925 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8983616 | 3927 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8983626 | 3928 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8983636 | 3929 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
8984575 | 3936 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984683 | 3938 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984691 | 3939 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984709 | 3941 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984717 | 3942 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984727 | 3943 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984737 | 3944 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984759 | 3945 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8984769 | 3946 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
8985054 | 3947 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038282 | 4148 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9041519 | 4151 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9041579 | 4152 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9041589 | 4153 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9041597 | 4154 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9042174 | 4155 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
10312569 | 4688 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4 | Dati identità - Commenti: Aula magna
10312665 | 4689 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4 | Dati identità - Commenti: Aula magna

# IfcBuildingElementProxy: Pulsante di sgancio:Pulsante di sgancio (6)
Type - Material: Vetro
Type - Altro - Categoria: Apparecchi elettrici; Nome famiglia: Pulsante di sgancio; Tipologia: Pulsante
Type - Dati identità - Commenti sul tipo: 1; Contrassegno tipo: 1; Label: GFCI; Nome del tipo: Pulsante di sgancio; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 1.1 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Pulsante di sgancio
Type - Pset_EnvironmentalImpactIndicators - Reference: Pulsante di sgancio
Material: Vetro, Pulsante, Bianco
Altro - Famiglia: Pulsante di sgancio: Pulsante di sgancio; Famiglia e tipo: Pulsante di sgancio: Pulsante di sgancio; ID tipo: Pulsante di sgancio: Pulsante di sgancio; Tipo: Pulsante di sgancio: Pulsante di sgancio
Dimensioni - Volume: 0.000496063 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Quota altimetrica da livello: 1.1 m
Name (Pulsante di sgancio:Pulsante di sgancio:...) | In | Contrassegno | Distanza_simbolo (m) | Nome | Livello = Livello abaco | Host
10691760 | B01 - Piano Interrato ELETTRICO | 2695 | 1.23171 | PEG-ILL.EME. | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10695412 | B01 - Piano Interrato ELETTRICO | 5065 | 0.5 | PEG-BT | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | Dati identità - Commenti: Aula magna
10695437 | B01 - Piano Interrato ELETTRICO | 5066 | 0.00896122 | PEG-FV | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | Dati identità - Commenti: Aula magna
10734709 | L00 - Piano Terra Piazza ELETTRICO | 5070 | 0.8053 | PEG-FV | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10734832 | L00 - Piano Terra Piazza ELETTRICO | 5071 | 0.498398 | PEG-BT | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
10734844 | L00 - Piano Terra Piazza ELETTRICO | 5072 | 0.0250481 | PEG-ILL.EME. | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt

# IfcBuildingElementProxy: QE da incasso-esterno a parete:EEQ_I_QeEsternoIp55 (76)
Type - Material: Interruttori
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: QE da incasso-esterno a parete; Tipologia: 54 (18x3)
Type - Dati identità - Commenti sul tipo: QE; Nome del tipo: EEQ_I_QeEsternoIp55
Type - Elettrico - Carichi - Carico apparente: 230 W
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_I_QeEsternoIp55
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_I_QeEsternoIp55
Material: Interruttori, Interruttore nero, Differenziale pulsante, Scatola, Guaina centralina, Scatola esterna centralina, Pulsanti apertura centralina, Vetro
Altro - Famiglia: QE da incasso-esterno a parete: EEQ_I_QeEsternoIp55; Famiglia e tipo: QE da incasso-esterno a parete: EEQ_I_QeEsternoIp55; ID tipo: QE da incasso-esterno a parete: EEQ_I_QeEsternoIp55; Tipo: QE da incasso-esterno a parete: EEQ_I_QeEsternoIp55
Dimensioni - Altezza: 0 m; Larghezza: 0 m; Lunghezza: 0 m; Volume: 0.033548 m3
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase A carico apparente capicorda passanti: 0 W; Fase A carico apparente circuito derivato: 0 W; Fase B carico apparente: 0 W; Fase B carico apparente capicorda passanti: 0 W; Fase B carico apparente circuito derivato: 0 W; Fase C carico apparente: 0 W; Fase C carico apparente capicorda passanti: 0 W; Fase C carico apparente circuito derivato: 0 W; Fattore di richiesta totale: 100; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Elettrico - Circuiti - Capicorda alimentazione secondaria: yes; Capicorda passanti: yes; Corrente nominale interruttore automatico principale: 1 A; Dati elettrici: 230 V/1-0 W; Opzione numerazione circuiti: Default
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Prospetto di default: 1.3 m
Name (QE da incasso-esterno a parete:...) | In | Contrassegno | Nome quadro = Nome | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
QEPT-B:8781372 | L00 - Piano Terra Piazza ELETTRICO | 539 | QEPT-B | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.819633
QELP:9417320 | B01 - Piano Interrato ELETTRICO | 564 | QELP | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.822205
QE WPTE.021:9417636 | L00 - Piano Terra Piazza ELETTRICO | 568 | QE WPTE.021 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.020:9417647 | L00 - Piano Terra Piazza ELETTRICO | 569 | QE WPTE.020 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.019:9417802 | L00 - Piano Terra Piazza ELETTRICO | 570 | QE WPTE.019 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.045:9417990 | L00 - Piano Terra Piazza ELETTRICO | 571 | QE WPTE.045 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.018:9418097 | L00 - Piano Terra Piazza ELETTRICO | 572 | QE WPTE.018 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.017:9418260 | L00 - Piano Terra Piazza ELETTRICO | 573 | QE WPTE.017 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.012:9418447 | L00 - Piano Terra Piazza ELETTRICO | 574 | QE WPTE.012 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.013:9418487 | L00 - Piano Terra Piazza ELETTRICO | 575 | QE WPTE.013 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WPTE.003:9418720 | L00 - Piano Terra Piazza ELETTRICO | 576 | QE WPTE.003 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 1
QE WPTE.004:9418748 | L00 - Piano Terra Piazza ELETTRICO | 577 | QE WPTE.004 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 1
QE WP01.059:9418913 | L00 - Piano Terra Piazza ELETTRICO | 578 | QE WP01.059 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.060:9418990 | L00 - Piano Terra Piazza ELETTRICO | 579 | QE WP01.060 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.045:9419207 | L00 - Piano Terra Piazza ELETTRICO | 580 | QE WP01.045 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.044:9419427 | L00 - Piano Terra Piazza ELETTRICO | 581 | QE WP01.044 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.043:9419530 | L00 - Piano Terra Piazza ELETTRICO | 582 | QE WP01.043 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.042:9419760 | L00 - Piano Terra Piazza ELETTRICO | 583 | QE WP01.042 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.041:9419893 | L00 - Piano Terra Piazza ELETTRICO | 584 | QE WP01.041 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.040:9420054 | L00 - Piano Terra Piazza ELETTRICO | 585 | QE WP01.040 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.039:9420154 | L00 - Piano Terra Piazza ELETTRICO | 586 | QE WP01.039 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.038:9420229 | L00 - Piano Terra Piazza ELETTRICO | 587 | QE WP01.038 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.037:9420391 | L00 - Piano Terra Piazza ELETTRICO | 588 | QE WP01.037 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.036:9420639 | L00 - Piano Terra Piazza ELETTRICO | 589 | QE WP01.036 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.035:9420826 | L00 - Piano Terra Piazza ELETTRICO | 590 | QE WP01.035 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.034:9421009 | L00 - Piano Terra Piazza ELETTRICO | 591 | QE WP01.034 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.033:9421094 | L00 - Piano Terra Piazza ELETTRICO | 592 | QE WP01.033 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.032:9421304 | L00 - Piano Terra Piazza ELETTRICO | 593 | QE WP01.032 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.019:9421467 | L00 - Piano Terra Piazza ELETTRICO | 595 | QE WP01.019 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.016:9421714 | L00 - Piano Terra Piazza ELETTRICO | 596 | QE WP01.016 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.017:9421932 | L00 - Piano Terra Piazza ELETTRICO | 597 | QE WP01.017 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.005:9422079 | L00 - Piano Terra Piazza ELETTRICO | 598 | QE WP01.005 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP01.003:9422464 | L00 - Piano Terra Piazza ELETTRICO | 599 | QE WP01.003 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP02.045:9423048 | L02 - Piano Secondo ELETTRICO | 605 | QE WP02.045 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.044:9423055 | L02 - Piano Secondo ELETTRICO | 606 | QE WP02.044 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.043:9423179 | L02 - Piano Secondo ELETTRICO | 607 | QE WP02.043 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.042:9423320 | L02 - Piano Secondo ELETTRICO | 608 | QE WP02.042 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.041:9423412 | L02 - Piano Secondo ELETTRICO | 609 | QE WP02.041 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.040:9423525 | L02 - Piano Secondo ELETTRICO | 610 | QE WP02.040 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.039:9423677 | L02 - Piano Secondo ELETTRICO | 611 | QE WP02.039 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.038:9423766 | L02 - Piano Secondo ELETTRICO | 612 | QE WP02.038 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.037:9423854 | L02 - Piano Secondo ELETTRICO | 613 | QE WP02.037 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.036:9423959 | L02 - Piano Secondo ELETTRICO | 614 | QE WP02.036 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.035:9424070 | L02 - Piano Secondo ELETTRICO | 615 | QE WP02.035 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.034:9424196 | L02 - Piano Secondo ELETTRICO | 616 | QE WP02.034 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.033:9424396 | L02 - Piano Secondo ELETTRICO | 617 | QE WP02.033 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.032:9424491 | L02 - Piano Secondo ELETTRICO | 618 | QE WP02.032 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.031:9424625 | L02 - Piano Secondo ELETTRICO | 619 | QE WP02.031 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.030:9425153 | L02 - Piano Secondo ELETTRICO | 620 | QE WP02.030 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.029:9425249 | L02 - Piano Secondo ELETTRICO | 621 | QE WP02.029 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.028:9425405 | L02 - Piano Secondo ELETTRICO | 622 | QE WP02.028 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.027:9425472 | L02 - Piano Secondo ELETTRICO | 623 | QE WP02.027 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.026:9425616 | L02 - Piano Secondo ELETTRICO | 624 | QE WP02.026 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.025:9425733 | L02 - Piano Secondo ELETTRICO | 625 | QE WP02.025 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.015:9425835 | L02 - Piano Secondo ELETTRICO | 626 | QE WP02.015 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.014:9425987 | L02 - Piano Secondo ELETTRICO | 627 | QE WP02.014 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.013:9426064 | L02 - Piano Secondo ELETTRICO | 628 | QE WP02.013 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.012:9426150 | L02 - Piano Secondo ELETTRICO | 629 | QE WP02.012 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.011:9426239 | L02 - Piano Secondo ELETTRICO | 630 | QE WP02.011 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.003:9426562 | L02 - Piano Secondo ELETTRICO | 633 | QE WP02.003 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.004:9426731 | L02 - Piano Secondo ELETTRICO | 634 | QE WP02.004 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.005:9426794 | L02 - Piano Secondo ELETTRICO | 635 | QE WP02.005 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.006:9426911 | L02 - Piano Secondo ELETTRICO | 636 | QE WP02.006 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.007:9427014 | L02 - Piano Secondo ELETTRICO | 637 | QE WP02.007 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QELA:9813425 | B01 - Piano Interrato ELETTRICO | 559 | QELA | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 0.822205 | Dati identità - Commenti: Aula magna
QETE:9892052 | B01 - Piano Interrato ELETTRICO | 566 | QETE | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.822205
QEUAM:9892557 | B01 - Piano Interrato ELETTRICO | 594 | QEUAM | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.822205 | Dati identità - Commenti: Aula magna
QE WPTE.015:10297793 | L00 - Piano Terra Piazza ELETTRICO | 642 | QE WPTE.015 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE RECEPTION SX:10297827 | L00 - Piano Terra Piazza ELETTRICO | 643 | QE RECEPTION SX | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE RECEPTION DX:10297857 | L00 - Piano Terra Piazza ELETTRICO | 644 | QE RECEPTION DX | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP01.046:10301983 | L00 - Piano Terra Piazza ELETTRICO | 646 | QE WP01.046 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1
QE WP02.010:10305993 | L02 - Piano Secondo ELETTRICO | 647 | QE WP02.010 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QE WP02.009:10306012 | L02 - Piano Secondo ELETTRICO | 648 | QE WP02.009 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3
QERAM:10309044 | L00 - Piano Terra Piazza ELETTRICO | 649 | QERAM | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.3 | Dati identità - Commenti: Aula magna
QEMP:10666186 | B01 - Piano Interrato ELETTRICO | 664 | QEMP | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.3 | Dati identità - Commenti: Aula magna
QEPP:10666196 | B01 - Piano Interrato ELETTRICO | 665 | QEPP | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.3 | Dati identità - Commenti: Aula magna

# IfcBuildingElementProxy: Quadro Elettrico componibile:EEQ_I_Qe (14)
Type - Material: Plastic RAL 7016
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Quadro Elettrico componibile
Type - Dati identità - Commenti sul tipo: QE; Nome del tipo: EEQ_I_Qe; Numero OmniClass: 23.80.30.11.17; Titolo OmniClass: Distribution Boards and Control Panels
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_I_Qe
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_I_Qe
Material: Plastic RAL 7016, Steel sheet metal with electrophoresis treatment + hot-polymerised polyester epoxy powder
Altro - Additional Plinth: no; Famiglia: Quadro Elettrico componibile: EEQ_I_Qe; Famiglia e tipo: Quadro Elettrico componibile: EEQ_I_Qe; ID tipo: Quadro Elettrico componibile: EEQ_I_Qe; module4: EMPTY; module5: EMPTY; module6: EMPTY; module7: EMPTY; Plinth100mm: yes; Show Clearance: no; Tipo: Quadro Elettrico componibile: EEQ_I_Qe
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase A carico apparente capicorda passanti: 0 W; Fase A carico apparente circuito derivato: 0 W; Fase B carico apparente: 0 W; Fase B carico apparente capicorda passanti: 0 W; Fase B carico apparente circuito derivato: 0 W; Fase C carico apparente: 0 W; Fase C carico apparente capicorda passanti: 0 W; Fase C carico apparente circuito derivato: 0 W; Fattore di richiesta totale: 100; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Elettrico - Circuiti - Capicorda alimentazione secondaria: yes; Capicorda passanti: yes; Opzione numerazione circuiti: Default; Corrente nominale interruttore automatico principale: 1 A; Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Quota altimetrica da livello: 0 m
Name (Quadro Elettrico componibile:...) | In | module1 | module2 | module3 | Contrassegno | Volume (m3) | Nome quadro | Livello | Host
QEA:9417113 | B01 - Piano Interrato ELETTRICO | 800x250 plain | EMPTY | EMPTY | 563 | 0.161498 | QEA | Livello: B01 - Piano Interrato ELETTRICO | Livello : B01 - Piano Interrato ELETTRICO
QEP1-A:9422832 | L00 - Piano Terra Piazza ELETTRICO | 800x250 plain | EMPTY | EMPTY | 600 | 0.161498 | QEP1-A | Livello: L01 - Piano Primo ELETTRICO | Livello : L01 - Piano Primo ELETTRICO
QEP1-B:9422929 | L00 - Piano Terra Piazza ELETTRICO | 800x250 plain | EMPTY | EMPTY | 601 | 0.161498 | QEP1-B | Livello: L01 - Piano Primo ELETTRICO | Livello : L01 - Piano Primo ELETTRICO
QEP1-C:9422987 | L00 - Piano Terra Piazza ELETTRICO | 800x250 plain | EMPTY | EMPTY | 602 | 0.161498 | QEP1-C | Livello: L01 - Piano Primo ELETTRICO | Livello : L01 - Piano Primo ELETTRICO
QEP2-B:9427210 | L02 - Piano Secondo ELETTRICO | 800x250 plain | EMPTY | EMPTY | 638 | 0.161498 | QEP2-B | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO
QEP2-A:9427308 | L02 - Piano Secondo ELETTRICO | 800x250 plain | EMPTY | EMPTY | 641 | 0.161498 | QEP2-A | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO
QEPT-A:10294848 | L00 - Piano Terra Piazza ELETTRICO | 800x250 plain | 800x250 plain | duct 300 x250 | 640 | 0.392239 | QEPT-A | Livello: L00 - Piano Terra Piazza ELETTRICO | Livello : L00 - Piano Terra Piazza ELETTRICO
QEAM:10309128 | B01 - Piano Interrato ELETTRICO | 800x250 plain | EMPTY | EMPTY | 650 | 0.161498 | QEAM | Livello: B01 - Piano Interrato ELETTRICO | Livello : B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
QECDZP3:10314829 | L02 - Piano Secondo ELETTRICO | 800x250 plain | EMPTY | EMPTY | 651 | 0.161498 | QECDZP3 | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO
QEPV:10483082 | L02 - Piano Secondo ELETTRICO | 800x250 plain | EMPTY | EMPTY | 657 | 0.161498 | QEPV | Livello: L02 - Piano Secondo ELETTRICO | Livello : L02 - Piano Secondo ELETTRICO
QGMT:10575350 | B01 - Piano Interrato ELETTRICO | duct 300 x650 | duct 300 x650 | 800x650 plain | 658 | 0.529696 | QGMT | Livello: B01 - Piano Interrato ELETTRICO | Livello : B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
QESC:10575395 | B01 - Piano Interrato ELETTRICO | 800x250 plain | EMPTY | EMPTY | 660 | 0.161498 | QESC | Livello: B01 - Piano Interrato ELETTRICO | Livello : B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
QGBT:10665530 | B01 - Piano Interrato ELETTRICO | duct 300 x650 | duct 300 x650 | 800x650 plain | 663 | 0.529696 | QGBT | Livello: B01 - Piano Interrato ELETTRICO | Livello : B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
QUEG UPS:10666463 | L00 - Piano Terra Piazza ELETTRICO | 800x250 plain | EMPTY | EMPTY | 668 | 0.161498 | QUEG UPS | Livello: L00 - Piano Terra Piazza ELETTRICO | Livello : L00 - Piano Terra Piazza ELETTRICO

# IfcBuildingElementProxy: Rack:EEQ_I_Rack (11)
Type - Material: Metallo
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Rack; Simbolo: Rack
Type - Dati identità - Commenti sul tipo: Impianto dati; Nome del tipo: EEQ_I_Rack
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_BuildingElementProxyCommon - IsExternal: no; Reference: EEQ_I_Rack
Type - Pset_EnvironmentalImpactIndicators - Reference: EEQ_I_Rack
Material: Metallo, Plastica, Interruttore, Attacco presa, Plastica verde, Patch panel, Default, Switch, Fault, Power, Dati, Maniglia, Vetro, Rack
Altro - Famiglia: Rack: EEQ_I_Rack; Famiglia e tipo: Rack: EEQ_I_Rack; ID tipo: Rack: EEQ_I_Rack; Tipo: Rack: EEQ_I_Rack
Dimensioni - Volume: 0.293468 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Quota altimetrica da livello: 0 m
Visibilità - Switch 1: yes; Switch 10: yes; Switch 2: yes; Switch 3: yes; Switch 4: yes; Switch 5: yes; Switch 6: yes; Switch 7: yes; Switch 8: yes; Switch 9: yes; UPS: no
Name (Rack:...) | In | Contrassegno | Nome quadro | Livello | Host
RACK PT-B:9033562 | L00 - Piano Terra Piazza ELETTRICO | 542 | RACK PT-B | Livello: L00 - Piano Terra Piazza ELETTRICO | Livello : L00 - Piano Terra Piazza ELETTRICO
RACK P1-B:9035149 | L00 - Piano Terra Piazza ELETTRICO | 546 | RACK P1-B | Livello: L01 - Piano Primo ELETTRICO | Livello : L01 - Piano Primo ELETTRICO
RACK PT-AM:9036514 | L00 - Piano Terra Piazza ELETTRICO | 547 | RACK PT-AM | Livello: L00 - Piano Terra Piazza ELETTRICO | Livello : L00 - Piano Terra Piazza ELETTRICO
