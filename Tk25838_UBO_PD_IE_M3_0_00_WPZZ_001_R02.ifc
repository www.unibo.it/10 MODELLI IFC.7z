Properties of the parts of a building model (IFC4), part 23 of 23

# IfcLightFixture: vie di esodo_incasso:Bottom (35)
Name (vie di esodo_incasso:Bottom:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9517635 | L00 - Piano Terra Piazza ELETTRICO | 5998 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9517672 | L00 - Piano Terra Piazza ELETTRICO | 5999 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9517807 | L00 - Piano Terra Piazza ELETTRICO | 6000 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9518821 | L00 - Piano Terra Piazza ELETTRICO | 6007 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 4
9518872 | L00 - Piano Terra Piazza ELETTRICO | 6008 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9518917 | L00 - Piano Terra Piazza ELETTRICO | 6009 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9518989 | L00 - Piano Terra Piazza ELETTRICO | 6010 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9519029 | L00 - Piano Terra Piazza ELETTRICO | 6011 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9519835 | L00 - Piano Terra Piazza ELETTRICO | 6017 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9519981 | L00 - Piano Terra Piazza ELETTRICO | 6018 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9519992 | L00 - Piano Terra Piazza ELETTRICO | 6019 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9520124 | L00 - Piano Terra Piazza ELETTRICO | 6021 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9520405 | L00 - Piano Terra Piazza ELETTRICO | 6024 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9520437 | L00 - Piano Terra Piazza ELETTRICO | 6025 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9520447 | L00 - Piano Terra Piazza ELETTRICO | 6026 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9520535 | L00 - Piano Terra Piazza ELETTRICO | 6028 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9520556 | L00 - Piano Terra Piazza ELETTRICO | 6029 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 2.375
9520742 | L00 - Piano Terra Piazza ELETTRICO | 6031 | Livello: L01 - Piano Primo ELETTRICO | Dispositivo ottico acustico allarme incendio : DFA_I_DispositivoOtticoAcusticoAllarmeIncendio | 2.3055
9520815 | L00 - Piano Terra Piazza ELETTRICO | 6032 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 2.3055
9520886 | L00 - Piano Terra Piazza ELETTRICO | 6033 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 2.3055
9520912 | L00 - Piano Terra Piazza ELETTRICO | 6034 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 2.3055
9520941 | L00 - Piano Terra Piazza ELETTRICO | 6035 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 2.3055
9521301 | L00 - Piano Terra Piazza ELETTRICO | 6041 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 2.3055
9523001 | L02 - Piano Secondo ELETTRICO | 6044 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.08
9523071 | L02 - Piano Secondo ELETTRICO | 6045 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 2.08
9523216 | L02 - Piano Secondo ELETTRICO | 6049 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9523256 | L02 - Piano Secondo ELETTRICO | 6050 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3

# IfcLightFixture: vie di esodo_incasso:Bottom cartello (10)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Zumtobel_Metal_Aluminium
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: vie di esodo_incasso
Type - Dati identità - Nome del tipo: Bottom cartello; Numero OmniClass: 23.80.70.11; Titolo OmniClass: Luminaries for Internal Lighting
Type - Dimensioni - Depth: 0.065 m; Height: 0.2214 m; Width: 0.3 m
Type - Elettrico - Commenti sul wattaggio: ILL SIC; Lampada: LED; Voltage: 24 V
Type - Elettrico - Carichi - Carico apparente: 4.5 W
Type - Grafica - Escape Bottom: yes; Escape Left & Right: no
Type - Materiali e finiture - Body: Zumtobel_Metal_Aluminium
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: Bottom cartello
Type - Pset_LightFixtureTypeCommon - Reference: Bottom cartello
Material: Zumtobel_Metal_Aluminium, Zumtobel_Escape_Sign_White_Self_Illumination, Zumtobel_Escape_Sign_Green_Self_Illumination, Zumtobel_PMMA_Semitransparent
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: vie di esodo_incasso: Bottom cartello; Famiglia e tipo: vie di esodo_incasso: Bottom cartello; ID tipo: vie di esodo_incasso: Bottom cartello; Tipo: vie di esodo_incasso: Bottom cartello
Dimensioni - Volume: 0.000516749 m3
Elettrico - Circuiti - Dati elettrici: 24 V/1-0 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Livello abaco: Livello: L00 - Piano Terra Piazza ELETTRICO
Name (vie di esodo_incasso:Bottom cartello:...) | Contrassegno | Host | Quota altimetrica da livello (m)
9514076 | 5972 | <non associato> | 0.2
9514168 | 5973 | <non associato> | 0.2
9516915 | 5991 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.375
9517013 | 5992 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9517097 | 5993 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9517104 | 5994 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9520008 | 6020 | <non associato> | 2.375
9520280 | 6022 | <non associato> | 2.375
9520297 | 6023 | <non associato> | 2.375
9524452 | 6069 | <non associato> | 2.375

# IfcLightFixture: vie di esodo_incasso:Left & Right (16)
Type - Material: Zumtobel_Metal_Aluminium
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: vie di esodo_incasso
Type - Dati identità - Nome del tipo: Left & Right; Numero OmniClass: 23.80.70.11; Titolo OmniClass: Luminaries for Internal Lighting
Type - Dimensioni - Depth: 0.065 m; Height: 0.2214 m; Width: 0.3 m
Type - Elettrico - Commenti sul wattaggio: ILL SIC; Lampada: LED; Voltage: 24 V
Type - Elettrico - Carichi - Carico apparente: 4.5 W
Type - Grafica - Escape Bottom: no; Escape Left & Right: yes
Type - Materiali e finiture - Body: Zumtobel_Metal_Aluminium
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: Left & Right
Type - Pset_LightFixtureTypeCommon - Reference: Left & Right
Material: Zumtobel_Metal_Aluminium, Zumtobel_Escape_Sign_Green_Self_Illumination, Zumtobel_Escape_Sign_White_Self_Illumination, Zumtobel_PMMA_Semitransparent
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: vie di esodo_incasso: Left & Right; Famiglia e tipo: vie di esodo_incasso: Left & Right; ID tipo: vie di esodo_incasso: Left & Right; Tipo: vie di esodo_incasso: Left & Right
Dimensioni - Volume: 0.000516749 m3
Elettrico - Circuiti - Dati elettrici: 24 V/1-0 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Name (vie di esodo_incasso:Left & Right:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9516455 | B01 - Piano Interrato ELETTRICO | 5986 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9516676 | B01 - Piano Interrato ELETTRICO | 5989 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9519226 | L00 - Piano Terra Piazza ELETTRICO | 6012 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9519274 | L00 - Piano Terra Piazza ELETTRICO | 6013 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9520468 | L00 - Piano Terra Piazza ELETTRICO | 6027 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9520582 | L00 - Piano Terra Piazza ELETTRICO | 6030 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9521022 | L00 - Piano Terra Piazza ELETTRICO | 6036 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9521086 | L00 - Piano Terra Piazza ELETTRICO | 6037 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9521122 | L00 - Piano Terra Piazza ELETTRICO | 6038 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9521196 | L00 - Piano Terra Piazza ELETTRICO | 6039 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9521257 | L00 - Piano Terra Piazza ELETTRICO | 6040 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3
9521452 | L02 - Piano Secondo ELETTRICO | 6042 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9521525 | L02 - Piano Secondo ELETTRICO | 6043 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9523104 | L02 - Piano Secondo ELETTRICO | 6046 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9523122 | L02 - Piano Secondo ELETTRICO | 6047 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9523152 | L02 - Piano Secondo ELETTRICO | 6048 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3

# IfcSwitchingDevice: Dispositivo segnalazione chiamata ottico-acustico:DNC_I_DispositivoSegnalazioneChiamata (16)
Type - Material: Plastica rossa
Type - Altro - Categoria: Dispositivi chiamata infermiera; Nome famiglia: Dispositivo segnalazione chiamata ottico-acustico; Tipologia: Segnalatore chiamata
Type - Dati identità - Label: GFCI; Nome del tipo: DNC_I_DispositivoSegnalazioneChiamata; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 03
Type - Vincoli - Prospetto di default: 2.25 m
Type - Pset_EnvironmentalImpactIndicators - Reference: DNC_I_DispositivoSegnalazioneChiamata
Type - Pset_SwitchingDeviceTypeCommon - Reference: DNC_I_DispositivoSegnalazioneChiamata
Material: Plastica rossa, Placca
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: Dispositivo segnalazione chiamata ottico-acustico: DNC_I_DispositivoSegnalazioneChiamata; Famiglia e tipo: Dispositivo segnalazione chiamata ottico-acustico: DNC_I_DispositivoSegnalazioneChiamata; ID tipo: Dispositivo segnalazione chiamata ottico-acustico: DNC_I_DispositivoSegnalazioneChiamata; Tipo: Dispositivo segnalazione chiamata ottico-acustico: DNC_I_DispositivoSegnalazioneChiamata
Dimensioni - Area: 0.0150693 m2; Distanza_simbolo: 0.5 m; Volume: 0.0000631112 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 2.25 m
Name (Dispositivo segnalazione chiamata ottico-acustico:DNC_I_DispositivoSegnalazioneChiamata:...) | In | Contrassegno | Livello = Livello abaco
10318857 | L00 - Piano Terra Piazza ELETTRICO | 203 | Livello: L01 - Piano Primo ELETTRICO
10318895 | L00 - Piano Terra Piazza ELETTRICO | 204 | Livello: L01 - Piano Primo ELETTRICO
10322437 | L00 - Piano Terra Piazza ELETTRICO | 209 | Livello: L01 - Piano Primo ELETTRICO
10322507 | L00 - Piano Terra Piazza ELETTRICO | 210 | Livello: L01 - Piano Primo ELETTRICO
10322959 | L00 - Piano Terra Piazza ELETTRICO | 213 | Livello: L01 - Piano Primo ELETTRICO
10322993 | L00 - Piano Terra Piazza ELETTRICO | 214 | Livello: L01 - Piano Primo ELETTRICO
10323300 | L00 - Piano Terra Piazza ELETTRICO | 217 | Livello: L00 - Piano Terra Piazza ELETTRICO
10323328 | L00 - Piano Terra Piazza ELETTRICO | 218 | Livello: L00 - Piano Terra Piazza ELETTRICO
10324245 | L00 - Piano Terra Piazza ELETTRICO | 227 | Livello: L00 - Piano Terra Piazza ELETTRICO
10324261 | L00 - Piano Terra Piazza ELETTRICO | 228 | Livello: L00 - Piano Terra Piazza ELETTRICO
10324422 | B01 - Piano Interrato ELETTRICO | 229 | Livello: B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
10324439 | B01 - Piano Interrato ELETTRICO | 230 | Livello: B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
10325301 | L02 - Piano Secondo ELETTRICO | 239 | Livello: L02 - Piano Secondo ELETTRICO
10325312 | L02 - Piano Secondo ELETTRICO | 240 | Livello: L02 - Piano Secondo ELETTRICO
10325482 | L02 - Piano Secondo ELETTRICO | 241 | Livello: L02 - Piano Secondo ELETTRICO
10325516 | L02 - Piano Secondo ELETTRICO | 242 | Livello: L02 - Piano Secondo ELETTRICO

# IfcSwitchingDevice: Pulsante a tirante chiamata:DNC_I_PulsanteATirante (16)
Type - Material: Plastica bianca
Type - Altro - Categoria: Dispositivi chiamata infermiera; Nome famiglia: Pulsante a tirante chiamata
Type - Dati identità - Label: GFCI; Nome del tipo: DNC_I_PulsanteATirante; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Dimensioni - Frutto_Altezza: 0.046 m; Frutto_Larghezza: 0.068 m; Placca_Altezza: 0.086 m; Placca_Larghezza: 0.122 m
Type - Elettrico - Load Classification: Receptacle; Switch Voltage: 230 V
Type - Vincoli - Prospetto di default: 2.25 m
Type - Pset_EnvironmentalImpactIndicators - Reference: DNC_I_PulsanteATirante
Type - Pset_SwitchingDeviceTypeCommon - Reference: DNC_I_PulsanteATirante
Material: Plastica bianca, Corda, Frutto, Placca
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: Pulsante a tirante chiamata: DNC_I_PulsanteATirante; Famiglia e tipo: Pulsante a tirante chiamata: DNC_I_PulsanteATirante; ID tipo: Pulsante a tirante chiamata: DNC_I_PulsanteATirante; Tipo: Pulsante a tirante chiamata: DNC_I_PulsanteATirante
Dimensioni - Area: 0.0248912 m2; Distanza_simbolo: 0.5 m; Volume: 0.000142893 m3
Elettrico - Load: 500 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt; Quota altimetrica da livello: 2.25 m
Name (Pulsante a tirante chiamata:DNC_I_PulsanteATirante:...) | In | Contrassegno | Livello = Livello abaco
10318360 | L00 - Piano Terra Piazza ELETTRICO | 199 | Livello: L01 - Piano Primo ELETTRICO
10318391 | L00 - Piano Terra Piazza ELETTRICO | 200 | Livello: L01 - Piano Primo ELETTRICO
10321961 | L00 - Piano Terra Piazza ELETTRICO | 205 | Livello: L01 - Piano Primo ELETTRICO
10322126 | L00 - Piano Terra Piazza ELETTRICO | 206 | Livello: L01 - Piano Primo ELETTRICO
10322769 | L00 - Piano Terra Piazza ELETTRICO | 211 | Livello: L01 - Piano Primo ELETTRICO
10322816 | L00 - Piano Terra Piazza ELETTRICO | 212 | Livello: L01 - Piano Primo ELETTRICO
10323623 | L00 - Piano Terra Piazza ELETTRICO | 219 | Livello: L00 - Piano Terra Piazza ELETTRICO
10323636 | L00 - Piano Terra Piazza ELETTRICO | 220 | Livello: L00 - Piano Terra Piazza ELETTRICO
10324052 | L00 - Piano Terra Piazza ELETTRICO | 225 | Livello: L00 - Piano Terra Piazza ELETTRICO
10324065 | L00 - Piano Terra Piazza ELETTRICO | 226 | Livello: L00 - Piano Terra Piazza ELETTRICO
10324793 | B01 - Piano Interrato ELETTRICO | 233 | Livello: B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
10324816 | B01 - Piano Interrato ELETTRICO | 234 | Livello: B01 - Piano Interrato ELETTRICO | Dati identità - Commenti: Aula magna
10324910 | L02 - Piano Secondo ELETTRICO | 235 | Livello: L02 - Piano Secondo ELETTRICO
10324923 | L02 - Piano Secondo ELETTRICO | 236 | Livello: L02 - Piano Secondo ELETTRICO
10325953 | L02 - Piano Secondo ELETTRICO | 245 | Livello: L02 - Piano Secondo ELETTRICO
10325965 | L02 - Piano Secondo ELETTRICO | 246 | Livello: L02 - Piano Secondo ELETTRICO

# IfcSwitchingDevice: Pulsante annullo chiamata:DNC_I_PulsanteAnnulloChiamata (16)
Type - Material: Immagine disabili
Type - Altro - Categoria: Dispositivi chiamata infermiera; Nome famiglia: Pulsante annullo chiamata; Tipologia: Annullo chiamata
Type - Dati identità - Label: GFCI; Nome del tipo: DNC_I_PulsanteAnnulloChiamata; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.65 m
Type - Pset_EnvironmentalImpactIndicators - Reference: DNC_I_PulsanteAnnulloChiamata
Type - Pset_SwitchingDeviceTypeCommon - Reference: DNC_I_PulsanteAnnulloChiamata
Material: Immagine disabili, Plastica rossa, Frutto, Placca
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Altro - Famiglia: Pulsante annullo chiamata: DNC_I_PulsanteAnnulloChiamata; Famiglia e tipo: Pulsante annullo chiamata: DNC_I_PulsanteAnnulloChiamata; ID tipo: Pulsante annullo chiamata: DNC_I_PulsanteAnnulloChiamata; Tipo: Pulsante annullo chiamata: DNC_I_PulsanteAnnulloChiamata
Dimensioni - Area: 0.0210435 m2; Distanza_simbolo: 0.5 m; Volume: 0.000129361 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
Name (Pulsante annullo chiamata:DNC_I_PulsanteAnnulloChiamata:...) | In | Contrassegno | Livello = Livello abaco | Quota altimetrica da livello (m)
10318461 | L00 - Piano Terra Piazza ELETTRICO | 202 | Livello: L01 - Piano Primo ELETTRICO | 1.2
10322195 | L00 - Piano Terra Piazza ELETTRICO | 207 | Livello: L01 - Piano Primo ELETTRICO | 1.2
10322228 | L00 - Piano Terra Piazza ELETTRICO | 208 | Livello: L01 - Piano Primo ELETTRICO | 1.2
10323081 | L00 - Piano Terra Piazza ELETTRICO | 215 | Livello: L01 - Piano Primo ELETTRICO | 1.2
10323111 | L00 - Piano Terra Piazza ELETTRICO | 216 | Livello: L01 - Piano Primo ELETTRICO | 1.2
10323785 | L00 - Piano Terra Piazza ELETTRICO | 221 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.65
10323799 | L00 - Piano Terra Piazza ELETTRICO | 222 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.65
10323914 | L00 - Piano Terra Piazza ELETTRICO | 223 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.65
10323929 | L00 - Piano Terra Piazza ELETTRICO | 224 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.65
10324686 | B01 - Piano Interrato ELETTRICO | 231 | Livello: B01 - Piano Interrato ELETTRICO | 0.65 | Dati identità - Commenti: Aula magna
10324697 | B01 - Piano Interrato ELETTRICO | 232 | Livello: B01 - Piano Interrato ELETTRICO | 0.65 | Dati identità - Commenti: Aula magna
10325169 | L02 - Piano Secondo ELETTRICO | 237 | Livello: L02 - Piano Secondo ELETTRICO | 0.65
10325184 | L02 - Piano Secondo ELETTRICO | 238 | Livello: L02 - Piano Secondo ELETTRICO | 0.65
10325789 | L02 - Piano Secondo ELETTRICO | 243 | Livello: L02 - Piano Secondo ELETTRICO | 0.65
10325800 | L02 - Piano Secondo ELETTRICO | 244 | Livello: L02 - Piano Secondo ELETTRICO | 0.65
10575609 | L00 - Piano Terra Piazza ELETTRICO | 247 | Livello: L01 - Piano Primo ELETTRICO | 1.2
