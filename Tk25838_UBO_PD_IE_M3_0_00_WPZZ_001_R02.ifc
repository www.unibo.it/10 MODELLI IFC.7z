Properties of the parts of a building model (IFC4), part 12 of 23

# IfcElectricAppliance: Dati:DDA_I_DatiDoppia (107)
Name (Dati:DDA_I_DatiDoppia:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
9056611 | L02 - Piano Secondo ELETTRICO | 1177 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9056702 | L02 - Piano Secondo ELETTRICO | 1178 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9057579 | L02 - Piano Secondo ELETTRICO | 1179 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9058294 | L02 - Piano Secondo ELETTRICO | 1180 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9058319 | L02 - Piano Secondo ELETTRICO | 1181 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.3
9061270 | L02 - Piano Secondo ELETTRICO | 1182 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9061287 | L02 - Piano Secondo ELETTRICO | 1183 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9061599 | L02 - Piano Secondo ELETTRICO | 1184 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9061813 | L02 - Piano Secondo ELETTRICO | 1185 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9062756 | L02 - Piano Secondo ELETTRICO | 1186 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9062815 | L02 - Piano Secondo ELETTRICO | 1187 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9062835 | L02 - Piano Secondo ELETTRICO | 1188 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9063164 | L02 - Piano Secondo ELETTRICO | 1189 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9063175 | L02 - Piano Secondo ELETTRICO | 1190 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9063418 | L02 - Piano Secondo ELETTRICO | 1191 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9063520 | L02 - Piano Secondo ELETTRICO | 1192 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9063637 | L02 - Piano Secondo ELETTRICO | 1193 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9064017 | L02 - Piano Secondo ELETTRICO | 1194 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9064182 | L02 - Piano Secondo ELETTRICO | 1195 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9064381 | L02 - Piano Secondo ELETTRICO | 1196 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | 04 - Unel doppia : EFX_I_UnelDoppia | 0.35
9245301 | L02 - Piano Secondo ELETTRICO | 1208 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9245381 | L02 - Piano Secondo ELETTRICO | 1210 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9245543 | L02 - Piano Secondo ELETTRICO | 1211 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9245557 | L02 - Piano Secondo ELETTRICO | 1212 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9245702 | L02 - Piano Secondo ELETTRICO | 1213 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9245855 | L00 - Piano Terra Piazza ELETTRICO | 1214 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
9245910 | L00 - Piano Terra Piazza ELETTRICO | 1215 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35

# IfcElectricAppliance: Dati:DDA_I_DatiDoppiaSoffitto (26)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Tipologia: 01 - Bipasso Singola; Nome famiglia: Dati
Type - Dati identità - Commenti sul tipo: Telecamera; Label: GFCI; Nome del tipo: DDA_I_DatiDoppiaSoffitto; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 02
Type - Vincoli - Prospetto di default: 0.55 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_DatiDoppiaSoffitto
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_DatiDoppiaSoffitto
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_DatiDoppiaSoffitto; Famiglia e tipo: Dati: DDA_I_DatiDoppiaSoffitto; ID tipo: Dati: DDA_I_DatiDoppiaSoffitto; Tipo: Dati: DDA_I_DatiDoppiaSoffitto
Dimensioni - Area: 0.0194455 m2; Distanza_simbolo: 0.5 m; Volume: 0.00013181 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m; Host: Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt
Name (Dati:DDA_I_DatiDoppiaSoffitto:...) | Contrassegno | Livello = Livello abaco | Quota altimetrica da livello (m)
9037637 | 1041 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
9037732 | 1043 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
9037786 | 1044 | Livello: L00 - Piano Terra Piazza ELETTRICO | 3
9038283 | 1054 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
9038463 | 1058 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
9038730 | 1060 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
9039500 | 1068 | Livello: L01 - Piano Primo ELETTRICO | 3
9039526 | 1070 | Livello: L01 - Piano Primo ELETTRICO | 3
9039736 | 1072 | Livello: L01 - Piano Primo ELETTRICO | 3.2
9039793 | 1074 | Livello: L01 - Piano Primo ELETTRICO | 3.2
9039801 | 1075 | Livello: L01 - Piano Primo ELETTRICO | 3.2
9039811 | 1076 | Livello: L01 - Piano Primo ELETTRICO | 3.2
9040534 | 1082 | Livello: L01 - Piano Primo ELETTRICO | 3
9040732 | 1084 | Livello: L01 - Piano Primo ELETTRICO | 3
9041724 | 1092 | Livello: L01 - Piano Primo ELETTRICO | 3.2
9041831 | 1095 | Livello: L01 - Piano Primo ELETTRICO | 3.2
9042208 | 1099 | Livello: L01 - Piano Primo ELETTRICO | 3.5
9042332 | 1104 | Livello: L01 - Piano Primo ELETTRICO | 3.5
9048071 | 1136 | Livello: L01 - Piano Primo ELETTRICO | 4
9048079 | 1137 | Livello: L01 - Piano Primo ELETTRICO | 4
9048105 | 1140 | Livello: L01 - Piano Primo ELETTRICO | 4
9048115 | 1141 | Livello: L01 - Piano Primo ELETTRICO | 4
9048212 | 1144 | Livello: L01 - Piano Primo ELETTRICO | 4
9242144 | 1202 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
9242151 | 1203 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4
9242236 | 1204 | Livello: L00 - Piano Terra Piazza ELETTRICO | 4

# IfcElectricAppliance: Dati:DDA_I_DatiTripla (111)
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Nome famiglia: Dati; Tipologia: 01 - Bipasso Singola
Type - Dati identità - Commenti sul tipo: DATI; Label: GFCI; Nome del tipo: DDA_I_DatiTripla; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 03
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_DatiTripla
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_DatiTripla
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_DatiTripla; Famiglia e tipo: Dati: DDA_I_DatiTripla; ID tipo: Dati: DDA_I_DatiTripla; Tipo: Dati: DDA_I_DatiTripla
Dimensioni - Area: 0.0197268 m2; Volume: 0.000131548 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Name (Dati:DDA_I_DatiTripla:...) | In | Contrassegno | Distanza_simbolo (m) | Livello = Livello abaco | Offset da host (m) | Host | Quota altimetrica da livello (m)
8715758 | L00 - Piano Terra Piazza ELETTRICO | 817 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8715958 | L00 - Piano Terra Piazza ELETTRICO | 818 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8716156 | L00 - Piano Terra Piazza ELETTRICO | 819 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8716448 | L00 - Piano Terra Piazza ELETTRICO | 820 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.2848
8717065 | L00 - Piano Terra Piazza ELETTRICO | 822 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8717200 | L00 - Piano Terra Piazza ELETTRICO | 823 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8718137 | L00 - Piano Terra Piazza ELETTRICO | 824 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8718226 | L00 - Piano Terra Piazza ELETTRICO | 825 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8718835 | L00 - Piano Terra Piazza ELETTRICO | 826 | 0.628747 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8718881 | L00 - Piano Terra Piazza ELETTRICO | 827 | 0.416368 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8719592 | L00 - Piano Terra Piazza ELETTRICO | 828 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8719651 | L00 - Piano Terra Piazza ELETTRICO | 829 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8720375 | L00 - Piano Terra Piazza ELETTRICO | 831 | 0.675385 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0.00114862 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8720426 | L00 - Piano Terra Piazza ELETTRICO | 832 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8720530 | L00 - Piano Terra Piazza ELETTRICO | 833 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8723652 | L00 - Piano Terra Piazza ELETTRICO | 837 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8723740 | L00 - Piano Terra Piazza ELETTRICO | 838 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8723860 | L00 - Piano Terra Piazza ELETTRICO | 839 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8828129 | L00 - Piano Terra Piazza ELETTRICO | 851 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8828183 | L00 - Piano Terra Piazza ELETTRICO | 852 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8828313 | L00 - Piano Terra Piazza ELETTRICO | 853 | 0.5 | Livello: L00 - Piano Terra Piazza ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_5_00_WPZZ_001_R01.rvt | 0.35
8967897 | L00 - Piano Terra Piazza ELETTRICO | 888 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8968093 | L00 - Piano Terra Piazza ELETTRICO | 889 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8968455 | L00 - Piano Terra Piazza ELETTRICO | 890 | 0.214068 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8968824 | L00 - Piano Terra Piazza ELETTRICO | 891 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8969331 | L00 - Piano Terra Piazza ELETTRICO | 892 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8969421 | L00 - Piano Terra Piazza ELETTRICO | 893 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8970372 | L00 - Piano Terra Piazza ELETTRICO | 896 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8970525 | L00 - Piano Terra Piazza ELETTRICO | 897 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8971381 | L00 - Piano Terra Piazza ELETTRICO | 898 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8971548 | L00 - Piano Terra Piazza ELETTRICO | 899 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8971769 | L00 - Piano Terra Piazza ELETTRICO | 900 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8972285 | L00 - Piano Terra Piazza ELETTRICO | 901 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8972651 | L00 - Piano Terra Piazza ELETTRICO | 902 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8972754 | L00 - Piano Terra Piazza ELETTRICO | 903 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8973309 | L00 - Piano Terra Piazza ELETTRICO | 904 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8973439 | L00 - Piano Terra Piazza ELETTRICO | 905 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8974094 | L00 - Piano Terra Piazza ELETTRICO | 906 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8974340 | L00 - Piano Terra Piazza ELETTRICO | 907 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8974927 | L00 - Piano Terra Piazza ELETTRICO | 908 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8975292 | L00 - Piano Terra Piazza ELETTRICO | 909 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8975678 | L00 - Piano Terra Piazza ELETTRICO | 910 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8976431 | L00 - Piano Terra Piazza ELETTRICO | 912 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8976672 | L00 - Piano Terra Piazza ELETTRICO | 913 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8976831 | L00 - Piano Terra Piazza ELETTRICO | 914 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8979172 | L00 - Piano Terra Piazza ELETTRICO | 915 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8979261 | L00 - Piano Terra Piazza ELETTRICO | 916 | 0.5 | Livello: L01 - Piano Primo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8985922 | L02 - Piano Secondo ELETTRICO | 925 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8985946 | L02 - Piano Secondo ELETTRICO | 926 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986086 | L02 - Piano Secondo ELETTRICO | 927 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986135 | L02 - Piano Secondo ELETTRICO | 928 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986511 | L02 - Piano Secondo ELETTRICO | 929 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986619 | L02 - Piano Secondo ELETTRICO | 930 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986685 | L02 - Piano Secondo ELETTRICO | 931 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986763 | L02 - Piano Secondo ELETTRICO | 932 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8986831 | L02 - Piano Secondo ELETTRICO | 933 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987008 | L02 - Piano Secondo ELETTRICO | 934 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987080 | L02 - Piano Secondo ELETTRICO | 935 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987125 | L02 - Piano Secondo ELETTRICO | 936 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987192 | L02 - Piano Secondo ELETTRICO | 937 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987391 | L02 - Piano Secondo ELETTRICO | 938 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987541 | L02 - Piano Secondo ELETTRICO | 939 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987629 | L02 - Piano Secondo ELETTRICO | 940 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987689 | L02 - Piano Secondo ELETTRICO | 941 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987799 | L02 - Piano Secondo ELETTRICO | 942 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987862 | L02 - Piano Secondo ELETTRICO | 943 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8987970 | L02 - Piano Secondo ELETTRICO | 944 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988031 | L02 - Piano Secondo ELETTRICO | 945 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988111 | L02 - Piano Secondo ELETTRICO | 946 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988191 | L02 - Piano Secondo ELETTRICO | 947 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988258 | L02 - Piano Secondo ELETTRICO | 948 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988410 | L02 - Piano Secondo ELETTRICO | 949 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988584 | L02 - Piano Secondo ELETTRICO | 950 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988647 | L02 - Piano Secondo ELETTRICO | 951 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988727 | L02 - Piano Secondo ELETTRICO | 952 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988871 | L02 - Piano Secondo ELETTRICO | 953 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8988942 | L02 - Piano Secondo ELETTRICO | 954 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989014 | L02 - Piano Secondo ELETTRICO | 955 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989083 | L02 - Piano Secondo ELETTRICO | 956 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989158 | L02 - Piano Secondo ELETTRICO | 957 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989215 | L02 - Piano Secondo ELETTRICO | 958 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989316 | L02 - Piano Secondo ELETTRICO | 959 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989384 | L02 - Piano Secondo ELETTRICO | 960 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989394 | L02 - Piano Secondo ELETTRICO | 961 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989550 | L02 - Piano Secondo ELETTRICO | 962 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989580 | L02 - Piano Secondo ELETTRICO | 963 | 0.893149 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989664 | L02 - Piano Secondo ELETTRICO | 964 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989781 | L02 - Piano Secondo ELETTRICO | 965 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989878 | L02 - Piano Secondo ELETTRICO | 966 | 0.855799 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989888 | L02 - Piano Secondo ELETTRICO | 967 | 0.421539 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8989976 | L02 - Piano Secondo ELETTRICO | 968 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990073 | L02 - Piano Secondo ELETTRICO | 969 | 0.896898 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990083 | L02 - Piano Secondo ELETTRICO | 970 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990192 | L02 - Piano Secondo ELETTRICO | 971 | 0.835898 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990238 | L02 - Piano Secondo ELETTRICO | 972 | 0.465231 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990441 | L02 - Piano Secondo ELETTRICO | 973 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990588 | L02 - Piano Secondo ELETTRICO | 974 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990622 | L02 - Piano Secondo ELETTRICO | 975 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990796 | L02 - Piano Secondo ELETTRICO | 976 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990911 | L02 - Piano Secondo ELETTRICO | 977 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8990927 | L02 - Piano Secondo ELETTRICO | 978 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991098 | L02 - Piano Secondo ELETTRICO | 979 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991126 | L02 - Piano Secondo ELETTRICO | 980 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991163 | L02 - Piano Secondo ELETTRICO | 981 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991352 | L02 - Piano Secondo ELETTRICO | 982 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8991409 | L02 - Piano Secondo ELETTRICO | 983 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8998926 | L02 - Piano Secondo ELETTRICO | 984 | 0.201466 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8998936 | L02 - Piano Secondo ELETTRICO | 985 | 0.206939 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8998946 | L02 - Piano Secondo ELETTRICO | 986 | 0.15311 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8999332 | L02 - Piano Secondo ELETTRICO | 987 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8999342 | L02 - Piano Secondo ELETTRICO | 988 | 0.5 | Livello: L02 - Piano Secondo ELETTRICO | 0 | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35

# IfcElectricAppliance: Dati:DDA_I_PresaRj45SingolaPavimento (7)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Tipologia: 01 - Bipasso Singola; Nome famiglia: Dati
Type - Dati identità - Commenti sul tipo: DATI; Label: GFCI; Nome del tipo: DDA_I_PresaRj45SingolaPavimento; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 0.55 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_PresaRj45SingolaPavimento
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_PresaRj45SingolaPavimento
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_PresaRj45SingolaPavimento; Famiglia e tipo: Dati: DDA_I_PresaRj45SingolaPavimento; ID tipo: Dati: DDA_I_PresaRj45SingolaPavimento; Tipo: Dati: DDA_I_PresaRj45SingolaPavimento
Dimensioni - Area: 0.0191643 m2; Distanza_simbolo: 0.5 m; Volume: 0.000132072 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (Dati:DDA_I_PresaRj45SingolaPavimento:...) | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
8722103 | 834 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8722113 | 835 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8722216 | 836 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.35
8827749 | 849 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 0.109124
8827816 | 850 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 0.109058
10303567 | 1291 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10303577 | 1292 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3

# IfcElectricAppliance: Dati:DDA_I_PresaRj45SingolaSoffitto (42)
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Tipologia: 01 - Bipasso Singola; Nome famiglia: Dati
Type - Dati identità - Commenti sul tipo: Telecamera; Label: GFCI; Nome del tipo: DDA_I_PresaRj45SingolaSoffitto; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 01
Type - Vincoli - Prospetto di default: 0.55 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_PresaRj45SingolaSoffitto
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_PresaRj45SingolaSoffitto
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_PresaRj45SingolaSoffitto; Famiglia e tipo: Dati: DDA_I_PresaRj45SingolaSoffitto; ID tipo: Dati: DDA_I_PresaRj45SingolaSoffitto; Tipo: Dati: DDA_I_PresaRj45SingolaSoffitto
Dimensioni - Area: 0.0191643 m2; Distanza_simbolo: 0.5 m; Volume: 0.000132072 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (Dati:DDA_I_PresaRj45SingolaSoffitto:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9037554 | L00 - Piano Terra Piazza ELETTRICO | 1040 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9037701 | L00 - Piano Terra Piazza ELETTRICO | 1042 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9037881 | L00 - Piano Terra Piazza ELETTRICO | 1046 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9037891 | L00 - Piano Terra Piazza ELETTRICO | 1047 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9037899 | L00 - Piano Terra Piazza ELETTRICO | 1048 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9038072 | L00 - Piano Terra Piazza ELETTRICO | 1051 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038186 | L00 - Piano Terra Piazza ELETTRICO | 1053 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038387 | L00 - Piano Terra Piazza ELETTRICO | 1056 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038397 | L00 - Piano Terra Piazza ELETTRICO | 1057 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038722 | L00 - Piano Terra Piazza ELETTRICO | 1059 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038748 | L00 - Piano Terra Piazza ELETTRICO | 1062 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038756 | L00 - Piano Terra Piazza ELETTRICO | 1063 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9039035 | L00 - Piano Terra Piazza ELETTRICO | 1064 | Livello: L00 - Piano Terra Piazza ELETTRICO | Collegamenti mancanti | 4
9039156 | L00 - Piano Terra Piazza ELETTRICO | 1065 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9039597 | L00 - Piano Terra Piazza ELETTRICO | 1071 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9040025 | L00 - Piano Terra Piazza ELETTRICO | 1077 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9040166 | L00 - Piano Terra Piazza ELETTRICO | 1078 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9040368 | L00 - Piano Terra Piazza ELETTRICO | 1079 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9040475 | L00 - Piano Terra Piazza ELETTRICO | 1080 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9040664 | L00 - Piano Terra Piazza ELETTRICO | 1083 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9040733 | L00 - Piano Terra Piazza ELETTRICO | 1085 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9041765 | L00 - Piano Terra Piazza ELETTRICO | 1093 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9041779 | L00 - Piano Terra Piazza ELETTRICO | 1094 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9041841 | L00 - Piano Terra Piazza ELETTRICO | 1096 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9041882 | L00 - Piano Terra Piazza ELETTRICO | 1098 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9042290 | L00 - Piano Terra Piazza ELETTRICO | 1100 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9042312 | L00 - Piano Terra Piazza ELETTRICO | 1102 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9042322 | L00 - Piano Terra Piazza ELETTRICO | 1103 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9042398 | L00 - Piano Terra Piazza ELETTRICO | 1105 | Livello: L01 - Piano Primo ELETTRICO | <non associato> | 3.5
9048008 | L00 - Piano Terra Piazza ELETTRICO | 1134 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9048063 | L00 - Piano Terra Piazza ELETTRICO | 1135 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9048087 | L00 - Piano Terra Piazza ELETTRICO | 1138 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9048097 | L00 - Piano Terra Piazza ELETTRICO | 1139 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9048136 | L00 - Piano Terra Piazza ELETTRICO | 1142 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9048291 | L00 - Piano Terra Piazza ELETTRICO | 1146 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9244757 | L00 - Piano Terra Piazza ELETTRICO | 1207 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
10307856 | L02 - Piano Secondo ELETTRICO | 1293 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10307871 | L02 - Piano Secondo ELETTRICO | 1294 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10308838 | L02 - Piano Secondo ELETTRICO | 1295 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10308914 | L02 - Piano Secondo ELETTRICO | 1296 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 0.3
10312702 | L00 - Piano Terra Piazza ELETTRICO | 1297 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
10312744 | L00 - Piano Terra Piazza ELETTRICO | 1298 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4

# IfcElectricAppliance: Dati:DDA_I_PuntoWifi (31)
Type - Material: Dati
Type - Altro - Categoria: Dispositivi dati; Tipologia: 01 - Bipasso Singola; Nome famiglia: Dati
Type - Dati identità - Commenti sul tipo: Telecamera; Label: GFCI; Nome del tipo: DDA_I_PuntoWifi; Numero OmniClass: 23.80.50.11.17; Titolo OmniClass: Ground Fault Receptacles
Type - Elettrico - Load Classification: Alimentazione; Switch Voltage: 120 V
Type - Grafica - Simbolo: 05
Type - Vincoli - Prospetto di default: 0.3 m
Type - Pset_ElectricApplianceTypeCommon - Reference: DDA_I_PuntoWifi
Type - Pset_EnvironmentalImpactIndicators - Reference: DDA_I_PuntoWifi
Material: Dati, Presa, Frutto, Placca
Pset_ElectricApplianceTypeCommon - sets with these values: 2
Altro - Famiglia: Dati: DDA_I_PuntoWifi; Famiglia e tipo: Dati: DDA_I_PuntoWifi; ID tipo: Dati: DDA_I_PuntoWifi; Tipo: Dati: DDA_I_PuntoWifi
Dimensioni - Area: 0.0191643 m2; Distanza_simbolo: 0.5 m; Volume: 0.000132072 m3
Elettrico - Load: 180 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Offset da host: 0 m
Name (Dati:DDA_I_PuntoWifi:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
9020848 | B01 - Piano Interrato ELETTRICO | 992 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9020946 | B01 - Piano Interrato ELETTRICO | 994 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.65
9036178 | L00 - Piano Terra Piazza ELETTRICO | 1032 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9036200 | L00 - Piano Terra Piazza ELETTRICO | 1033 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9036335 | L00 - Piano Terra Piazza ELETTRICO | 1034 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9037340 | L00 - Piano Terra Piazza ELETTRICO | 1037 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9037384 | L00 - Piano Terra Piazza ELETTRICO | 1038 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9037848 | L00 - Piano Terra Piazza ELETTRICO | 1045 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9038064 | L00 - Piano Terra Piazza ELETTRICO | 1050 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038344 | L00 - Piano Terra Piazza ELETTRICO | 1055 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9038740 | L00 - Piano Terra Piazza ELETTRICO | 1061 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9039516 | L00 - Piano Terra Piazza ELETTRICO | 1069 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9039783 | L00 - Piano Terra Piazza ELETTRICO | 1073 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9040483 | L00 - Piano Terra Piazza ELETTRICO | 1081 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9041437 | L00 - Piano Terra Piazza ELETTRICO | 1088 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9041659 | L00 - Piano Terra Piazza ELETTRICO | 1090 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9041849 | L00 - Piano Terra Piazza ELETTRICO | 1097 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.2
9042300 | L00 - Piano Terra Piazza ELETTRICO | 1101 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.5
9047225 | L00 - Piano Terra Piazza ELETTRICO | 1126 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9047273 | L00 - Piano Terra Piazza ELETTRICO | 1127 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9047281 | L00 - Piano Terra Piazza ELETTRICO | 1128 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9047289 | L00 - Piano Terra Piazza ELETTRICO | 1129 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9047453 | L00 - Piano Terra Piazza ELETTRICO | 1130 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9047512 | L00 - Piano Terra Piazza ELETTRICO | 1131 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9048177 | L00 - Piano Terra Piazza ELETTRICO | 1143 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9048283 | L00 - Piano Terra Piazza ELETTRICO | 1145 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4
9068785 | L02 - Piano Secondo ELETTRICO | 1197 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9068865 | L02 - Piano Secondo ELETTRICO | 1198 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9068915 | L02 - Piano Secondo ELETTRICO | 1199 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9068927 | L02 - Piano Secondo ELETTRICO | 1200 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3
9242136 | L00 - Piano Terra Piazza ELETTRICO | 1201 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4

# IfcFlowTerminal: Pozzetto monolitico tradizionale in PP 400x400 - PZ40:PZ40 400x400 (11)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Altro - Categoria: Apparecchi idraulici; Nome famiglia: Pozzetto monolitico tradizionale in PP 400x400 - PZ40
Type - Dati identità - Descrizione: Il pozzetto è predisposto sui quattro lati di alcuni diaframmi, facilmente asportabili per ottenere la possibilità di inserire i tubi sigilandoli eventualmente con silicone; Modello: Pozzetto monolitico tradizionale 400x400; Nome del tipo: PZ40 400x400; Nota chiave: PZ40 400x400; Produttore: First Plast S.R.L; URL: www.firstcor.com
Type - Dimensioni - A: 0.396 m; B: 0.386 m; Bi: 0.383 m; C: 0.396 m; D: 0.386 m; D10: 0.16 m; D11: 0.2 m; D12: 0.25 m; D5: 0.08 m; D7: 0.1 m; D9: 0.125 m; Di: 0.354 m; H: 0.4 m; H1: 0.3945 m; H2: 0.025 m
Type - Materiali e finiture - Materiale: POLIPROPILENE
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: PZ40 400x400
Type - Pset_ManufacturerTypeInformation - Manufacturer: First Plast S.R.L
Altro - Famiglia: Pozzetto monolitico tradizionale in PP 400x400 - PZ40: PZ40 400x400; Famiglia e tipo: Pozzetto monolitico tradizionale in PP 400x400 - PZ40: PZ40 400x400; ID tipo: Pozzetto monolitico tradizionale in PP 400x400 - PZ40: PZ40 400x400; Tipo: Pozzetto monolitico tradizionale in PP 400x400 - PZ40: PZ40 400x400
Dimensioni - Volume: 0.0077112 m3
Fasi - Fase di creazione: Nuova costruzione
Meccanica - Classificazione sistema: Mandata di sistema idronico,Tubo protettivo passerella,Acqua calda sanitaria
Vincoli - Livello: Livello: L00 - Piano Terra Piazza ELETTRICO; Offset da host: 0 m; Quota altimetrica da livello: 0 m; Host: Livello : L00 - Piano Terra Piazza ELETTRICO
Name (Pozzetto monolitico tradizionale in PP 400x400 - PZ40:PZ40 400x400:...) | Contrassegno | Pset_EnvironmentalImpactIndicators, sets with these values = Pset_ManufacturerTypeInformation, sets with these values
10343943 | 2
10344000 | 3 | 2
10344018 | 4 | 2
10344058 | 5 | 2
10344106 | 6 | 2
10344148 | 7 | 2
10344224 | 8 | 2
10344264 | 9 | 2
10344413 | 10 | 2
10344414 | 11 | 2
10344415 | 12 | 2

# IfcLightFixture: LFX_E_IguzziniMod.Bg19:LFX_E_IguzziniMod.Bg19 (53)
In: L00 - Piano Terra Piazza ELETTRICO
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_E_IguzziniMod.Bg19
Type - Costruzione - CFG_: ---_0001; Mounting Place: Floor; Mounting Type: Recessed
Type - Dati identità - Commenti sul tipo: Product without accessories; Descrizione: BG19 : External direct-light luminaire to be applied to the ground designed to use LED lamps with symmetrical optic. The product is made up of lamp compartment and body. The cylindrical body is made of extruded aluminium and subject to painting and chromate treatment. It houses three stainless-steel rods fixed to the base that make it highly shock-resistant. The product is anchored to the ground by means of a fixing base made of a corrosion-proof diecast aluminium alloy with low copper content. The polycarbonate diffuser screen is fixed to the component-holding box by a diecast-aluminium internal fixing ring. The sheet-aluminium lamp cover is designed to house accessories. The lid-hinging ring is made of diecast aluminium subject to painting and chromate treatment. The top of the fitting is closed by a diecast-aluminium external lid with bayonet-closing system and fixing bolt. The screw can be removed by a socket-head spanner (special spanner upon request). The superpure-aluminium reflector is fixed to the internal end cap by captive screws. The component-holding compartment is made of diecast aluminium. The temperature of all accessible parts never exceeds 75° C. All external screws are made of stainless steel A2. BG19.15 - Monochrome LED luminaire with electronic control gear - 4.9W 403lm - 4000K - Grey LI27 - Lamp LED neutral white (nr.4); Modello: BG19; Nome del tipo: LFX_E_IguzziniMod.Bg19; Product group: floor-recessed luminaires; Product Name: iWay bollard round; Produttore: iGuzzini; URL: http://relux.com/search/artfwd/igz___bg19/
Type - Dimensioni - Height: 0 m; Width: 0 m; Length: 0.09 m; Weight: 0 kg
Type - Elettrico - Number of Poles: 1; Commenti sul wattaggio: 1; Lampada: 1 x LED; Protection Class: Protection class; Protection Degree: Degree of protection; Standby Power: 0 W; System Power: 6.4 W; Voltage: 0 V
Type - Elettrico - Carichi - Power Factor: 1; Carico apparente: 6.4 W
Type - Elettrico - Illuminazione - Luminous efficacy: 34.6328 s3*lm/kg/m2
Type - Fotometrica - CIE Flux Codes: 9 71 98 99 55; Color Rendering: 75; Color Temperature: 4000K; Lamp count: 1; Lamp Light Flux: 403 lm; Lifetime: 50000 h; Socket: socket; System Light Flux: 221.65 lm
