Properties of the parts of a building model (IFC4), part 14 of 23

# IfcLightFixture: LFX_I_GewissGws3221Ap940:LFX_I_GewissGws3221Ap940 (96)
Type - Generale - Conversion date: 17.11.2016 20:48:02; OnlyDefault: yes; RlxApi version: 132055296; RlxData: ZN3q8ryccAAPERJRSxLoAAAAAAAAkAAAAAAAAAHH9FPkAf7Yb7fCEQFjjkd4QJ1hhiyLIBlgrCWUW7+Z03W9/Lrvm0hKhcWirWwvdVtoMHoW0gpCyup/KMu6Ki7N8db3ma6E0KYklQCLXrwWrX7IqkNc+HLQTIPJRxhp50u6h3v/O4fL69cpRyTXlrRoKZJRUOxByHpo+ntAWL2QTTRk3Hcw4SN6VLKOr2aKicpb4SZ4th+DVAgHmguNrmUv71obTfo6XKAzNI/QM5UX3e3hl8s1E8ChjUh3w7ZjXnSnk/ZHymFamjit0s5t1cbCJBUCSeJiQye67cc1YY2qRvzr+7C/O7C0K3CSIysaqBggJ1V0uCRnmkScNmcskoANFEpI6nc894QxOHJ5kjI1DgJbPH8fpWHJ+VoYVb6Rdgq/uwcNyJDLu3VXN5mfAeuuFpleflPKHnuFUMV4TrV+YwICFi/4FvnJ7Zie3HYtDVdQNpb6W5YIYup4G8QB7o/Ubj8UNCSdH6YlmjdLR2DaZmHVCKs4B90569NWIxO0mihjQmMJXc4cnz4BSxnJaXiNsJqlwHP9t1CMP7ZhDT30FNUpt2JTKlv6I0+2kzqTH7t4wsaBGh6QuXamknU+KU2n6UM3IJfS/aMNlR353ECHL0YQIElOC/gITDr5rgNiJZwqI+lUwDpI5o1Ufl08AG9kJmIssr8g0cip6OMYZ4i+6eXNBCyx4I84oaDdTlbmIjIo6hlic/fs1/wF1zcAVs+y+b1sGdDutCQHxOGKjPTZukJEFfvBYgNOGjTJOhGUXt/3Xh7zAJKsO2xj6IZSF4m5a0wqc97vsmFZzHMF46LxB5k4mpWFXLOdnftIurbSLRjAem7KSnyz9NibucNbsiPFHB7Uia12we0ChqTpq883n2rlAIZcaq1tWdLk2HkXkeMJNdZHVmcVS6BHfldfnTH85X9kboHxmLLGEz1j3G32Rs9J1tLDUhYLO4cXsDDy0nu3GkPxOidfbP+I/a1nn9mZ/SUgJfpaUlzPGBORArI+N31kfoZmqJA+G1xJaMDzJm//FOYN3dYMHVBiLRzOvvGUp7UPXKy3xIKeWTKqMw6Cw8el7BAooXLshFYy8CUmmxXkzsF+lTKJGgjECh84/dO9I6D+8XlAdhF88ayIbKM4gV3L+3Q7y0vUlxQWle5qN/BjM1zF4zPKDxg0mEKFnzzsOx3JeNswuU9yty/OOCCDaHrRXYfa1H+h0Atq5Wg4X1Qn6UePMLb8NVtoc7zDyqXOhtpwmbLJdbtQu3cAy4X7akBCogwpKnvVl3TkgDE+DByk/4gJrW5z8xDaH8aoRKpdRLBsk3bHkWMeL77EU2VAc7a749QeIelw48qeUiOG9DV/HTIeKP+IooFKW8e05L+T1JeXDTDWtYZqDJWv5SZY8crw7sWrN8o/I8N5Xv3DbH+7WsGg5VuyIxnPjW/oBrikciaieSFNZ4asYYfNHXgngaVDsSkBAdoLv8fehvCXB9OVGQ9i6rJRPiCj0JtOy5csV+21OW4tu0UNc+ivLPxBF7aQHiok88LQd3124iS+Fm+ablgVSizCo5+rfVxjoJmHI+yHCAv3ok3/1wWfDE2NYCSSe/D8X4KYTbYV3JgNQdbvirHsxmfDoMTZ6McZn0+OtItcTkZLtuvlYGIimXVRHpqh0dtM5PTOQ1nQdgZRzTO7S4BQtn17O5Q9XDwghYKRoxzRR93fhlXcw9O4UlCtGlZdoISXETiUnz5JlDwSS6KKgNkpv/Auv4tnxki7s7jA0dBPMKAv+2ozqBb4MkxlH4pR7p7C0zwOANeRmozb+oS1lHv5G/ogI5vJglzSFWtZZ5aBnkxcqMpZ5rWIImiSHgdc96Wnyj9oIHj1CPD6GT63a8Pwv6f29+HC5wJRZPcJ9NLwgBnHCDgU6UWfkecyx0ohhG4TR5cQEAkOE7oXu8cR/9SLIYDfOxmN6q04ZqU4hUFxnSRVasAokUu3EM2FMzGlH5YX96lJOqzBuclLW9IDUe0HLmr0CukI0aycEMqkYEUElcoMZXogDUgV2yPnFR0BGuCPj0pCOWumDOWgZOVosqhFacJKk+C+9nz7Krtb9JRfHdgXG7Rj2iXEEl4zhDeGMnYtJDSXWxXZCMpE4B5Abm3lbY7UXeAb6Q+GTRvC/Wd9ngPWKYzr1KNP4ZndwMsp3YlZgIqUPwo76aM2Lc9ynzsP+cPSeRsFgFHqfPe/ip7BXeCTLi1VD8mlBNiqWLOJzO9Mmbn0xGrDeM+r/Aowevc0P9L2bUKmZ/SaLqeFy2W/kOGMTcKapCDQbK6WoRZmlgkxyTjztu4uWX+jEE8Q4iCf6ujapvxShNld+2syesdgFNNqaEXNIPCg/aZvZKy2cn3h4YXsE1r5HEz5xYrVwnEQEXZVWPWeIEDcTCC2Oo6U0WHkzlcLWw66JoBcjbMOv8DPV1ZQh5avAAnV72n8QE+7YZWmpkzZpU32FL/Dp4IRRTjNCc+qy2T6UgJ+WRo0ARU5znKsi/FVqVaLn9EnHDS7n75CA/czgkP2puK2tCMug1jzORYDrS+tu5H+7PLX3uZtatTQj4dizlaay0NFSjMDPNEQLYRTMBnicuANVjqvYU4I/M1eraD6ZTMZ0vLrxv1oJr1BSTM/lygg4YGPpSyn4IWYxFshbOAOwPj+tsBDOuICPDE/IURUXCiKXGCWdCEVFFvzD/76entY4VOrWspNFfSKTI1HlYwp3XF494D9jw2S9lNyeNt4sfjTS19ULqw0MNJcgX/Z+zwEOf8xi0c8zTtf3F5eHa9ls6PQ51XxjY5I6e/fd/Dtv+8DkjNsDTUGo63efRRh6RzOOJ9EIQGX4Jc5RQpE1nyZUDFCQjmdHtTbQdt8fNvdNmoTRHZ738o+HXEoseFiUWNM+RcHw4NjtXBxZPwM+3NuWC/JCsnN+iglphRtbQX6JPTZSZonTWrc7pY1kMaHpdrvzau22aDFfDMBEnuTt6xlmDXiNOUQtfgUtr6vDyFYCTcAnKVKwhHi957cZXJfL39fddnD0Z/qDJ/W2tuBAAnj/nN5fKLfBh7ZBmT1+ctr9nc/RXZ1M9GNrhQi0ylSKBOXI4xW/S5jcGaj0RJLD9efFAuWsxFdIsZzWqHpgOexVyG1oneUeEm6QtyeSiGcH4XJwi2AW1OuT2RiGaP+8x60xus0VVUE6BP/cIfFDq4FMLL+r1N7bvRj3NAZVP2tOAxbNTlQcgl4N7B71+iKpYTEX+364ggEWICf+GmgYsHGfMN0t4Y+XJEJjUUH4PyNnRzGBveNjekGW95R/H0NlRd5B/dAVhJ75BkXJ74aDTNoJ9PLDQbdFuJkk42CpFWugawz2rSNy4XEu6OinTYHgdQa3ogFaThnt0AYzSHZwRvVe4YyA3LuXl9VJTHagSpxtBwWcxhvWZtChUgd5+UGjNmWOnZ/pdn0MkSRVRfFRf7CD++pqRqW5/fbrTHMoAqXgaa14QSYUdrFz48dViQBc1VHgiyz6hKLeO8rKhEeBCfoVpg8tJdEmarAAcZfgKLun4aDvnnMEL4uFnWn88trVaQ3aEQRc5byOXlg9HLXeka+q4HMrjIeZWdWV+OXoWDY60L9xu1h7kO32WBHeEMsTKyLIYiaS1G50UCzwlCn6jUphYhig9hE8SByepClOpP46jgRzs+HEhkH+/Wm70h+g6a+DhDh7HdVfqcBBlKOtzfqBhhW9YMyKCKtrHyuLVf4O4p+CouroOZJPfcWt2H9GfGRxrWKbnJ2LNS/q0zUvtNnZi5rwZ8L2nKqRZ7h214xQQWW3qD08h1Ste1NsH7fKrc4Jx8WritbvUqE/AHPGt5gmip6ixniNEryHlh4liTsAHz7If+jdjYz/pYK8O6c+TtvLOSJmwsNXcw5ssmDI0j2nr/P/bNk7lBnvPEStjYksUY3ae1hTp/dErh8ptT0Y1+Ek7tvAOaLSygwEgDHWuMQegkS9KFbAjSOhp6dNigJTKW7Zg5JG1yGiXuCDgnXEgaRJ7hgY1on+4i8f4fhJcpIMSu3mMoA38QKryXasgJWy/lwMlvvqw5ZcJUT0iEGtLIetPCxisS8U2yupjYGJtPvC3eqm1xyImLLOv3TdJP0GY+8Ox9ite9ahYAycjsvqr/FQN/sbhmmXTfdAOy8QG8iqxyzi7eddlzfn/BDbjzkkg8soVfnqvhRUaDLTf8n4mr7jiLPxFN8Iju79yKwEY/a2Wis68levBxmXqfYVlLA9legPeLhbSmG5cJKrO8I1QmA6F0ZyPoDCMEBbqI2kMSYpclI54DDCdpklIJUC/b7OMrek4qG7buvHaSeEEV4TTGtgHic+nYxbwCBvDv5iD/iq/ue1zGczlX8HMiHNx1ICmRGZ2ZTxGSiazCp5QwOIDgg2a2fLHbQyyLd9fBW+Uw2W9NtaGuKXSJjL7cDJ8px5tIQ3HAXhUXyjTqIoRhLTvK5IvNc9OPv3zP4YmNuDkbIns4uP09UR1VRqydESjlBFwoUG2NZfl95kAPOWtXeAv+3V1+LuCEh6BQOrlpbA1/TqpTCrtI43xx5MdPXqnOAdkfFb4eTce5e8h2jHZSC8IgdUOUFTLqhyc3gMEKOnmqhpjogSrMzKSFodAW9kMpL1IkGlDxsncHJTDkeIaC/cfb0Hd46TKBDKZQ+f5kp5hIqRxntHj0xIJRA8VK5N5LEFa/zaoCHi6aUsOYuQw/j8oy95btnuEqQa3eJJFWY9ZG5jaPJBdYhZ7Ro0h9mnuIVirwp2zYyzMdnFcGe+Uyt9T3FUO/S3TuNG+Cd5Jf87NAbr2wRkcVjovqqtU4r/m8cjXwFcQuOC6LG7xMP7rgREVhUaLUVkw8zsGivjJUwO1S9jueoHaCHZcg8f1w/P+ObCpn4HFU5i8l1KdxXkeBNaZATjYOTIJeYwbIjVOlPj5eGWq8XKqs2ZW55zX/SAXPAwXYlfS/zKhfs4A3eUxlSK1USCfna1zVMkz+UeSnsMGt02/ZgtKPGEAu+xbSsv93ZuNMnimaGFfhGrb81/GaXNlAFlUA9/4Otjqu2k7HjnYmca31icuczy2LGjaoibFALVjl0oOX1wxkJivsp5Z9SAmJQhiLoFk0RZUcohUQWy+6g74Lj436sIzj6sFzIahedS+zP3HgC8btSKxcSGSaLitEwSECtQuZ3pCFCMyjb2fFTJbwmlHCk7L9zkuqygh3jRTMB5s/FZLcjGLzL9dOdaQR1r0PfJ7PwnpAHdzxQCLMK5V7U+/vZ4/PNsweh5edDxtuEF0/BjNuDKujZ8yo8uuO1AxZHg9MZxJSIv0dECvgbbuju2edUwB2+iNVBnyx6NeP54lgGzajf2+B1EwSym5Op8/cQXiYzfCm8AQUWvfnQbWGht6FCNi2LEfVUINNXLz1zRV+WllKivg0a1Ij1BSn9QnR1dFHraqKijew0Ndr1t42ozBvFD/KZjsXPbCnrK8fRk7+mxI8xSW2giIwCp4Wt0d3LMcgwjmhuQrZS08rm2gP73SRWABN2mogfzB034lOnZKEiYyPr3X+NhVMwFZaswWYZsbcExL5cMgmUlk3JPftOm6NrTCcPVJ4AuNnZjPq7rGY9FsZTTRbGosNNk6snJiM2eDxJlMXIkFVhj2Y5OAvevSNJDzAWpDoh7Ogb4ObRUCytj6zn+Ij7skncrUbqXb3u9I+qJXA6r+uRNaI7EAduUZakSRWMPPtwMStJv2vkeDv23B28XFtKYPBEKWJjCH3r5IdWhkNbUNG8H4ErYUsrtV2AXf1Lzu5Ef8pvxHiXTnXPXDBl00Q0aMs3pnNhnyXKhI1x0XMh2jYnQfyhjo4unbQP5RD1ucSr4gLgfqNc219eUDa2a5lcwfS2FOfGmhVNfRqzIv5i8vOvwT8GlyOEqXhqM8I1z20VhkoL6lwyDQuYt3Ux4ak7gl6lbdnB9CduF8ZRyi6Z3qzSL0ivM5gw0ODXRxxK1Z3cBl9tvtzQDMQ9xgCXjvznj9ZPEdz87OTzYMneRMlxZMMCgkCTcNxeNu8g9cTMr9/Zc9V4TH94SgRt9zjVlU15luZQ6Qh39j54NEkMAnmoz8HzhSfZTlrvwR5AY7KXwAigp2N92w4hq9DDpjtuyHeLAkEYUeKr5tq6NNufN0DZbVR1PI/30GYPBBuaWzbtorUk94hKG6HK5nXXM1nLCGqZ2NqBiAn7V14wOeKb/No+yySQ5/i54c7KhmVAKTvp5mI+4Z1SkK35a33wm7roXTUPImu7n8AWXy/grcOqYqLAPlgrC+Ks6tYhRtXactfMAEVGV+I7RG+wJBeCTy4128YXhNi59AAuEABN8TTCg8cK/amwuYlMiDahRmm++19K6QgHrj21hAHLsd2v/2MREgJTBhzInuxjZsbZbIzizpXc6H21BSLmr/8Fa8l09bDlL0SQNdCr3z76M3/UDRnQ8EvmJ0oOgxpqrUjcI/42lG34GfLCOeXoZqMcCi7ZtSjrIMwmTOYy+WXpkXL0v3SC9SjmPEnkAZtuycvfoh73GombKiJNoM74BitEKeOeDauYaQ+Q7jOXrL8P1ZpNeJddZXDpx5xPiBojA5N9A4F6ihoSNUKQLOxbKWwyk55YFCbolcWFZCm3Zk4LhWyZmTZLRhScoo6amGaK6N0U9ILeQlB/0v+OxJ4s94hNOvLnIbGSfruOMFBL+Pq5sx7ia++vtW7kn2aYsRBQB6M5I36ExpkysIVdRdAl6A4c3W5zL4Fvk7PI+dn1Dtt4ous2dE36mVohu/S/y8pWvZzSONbhpKg+UVp79ZTEzKbi20Ot+iwhfUql6qS3eeydvIN28SSvWl7KkA2wdTQ3r85kZp7SUatqUKevSqbBY4dhOqPbg2s2paYV63PaFrxPxSXBL7QZQBAZ06DJ60XsmBfpGhSOAiiyn34RgP6AvUSX8rkL/YgBcVgHz9bVlCUhB13tkwON6oO7tuuZSNTJJD/6Ua5QrTzDnoQUnfZphsBRBgw+IiKAiOOG7DAY8mULdH14sAClV+F9SNcE/g65LCe8r1KhVCObSfMX8N+LY9OcZ2QgIYtW0x9yGlXpYc2IQ1CaE7sJvuU2+qbrY7P8IJO5qoZvvQTkuHiHFou7vJuIBHUdHe08NXTqStf5QXfI41kLwfMfuK4LucreFZi3YOllh30SUO190yg4JSnqRcolItnlldWTfrBrKUluggjCECP88oV5Z65ihSGmSp2WYqtfYM8mOd310+tRhhajr3XCQzFDEbD7bGf30Q1V5ohD7QjBohPaiynAVNQHK8I/M9fjgyyFMUeSc8j9KK+PjzU955OD3Jm2ECssR4YIdWiVahnj5VenYeBEE3wIRyWIBzmriw9/7B5D2ZkaBg83TV1rag0PK9K0jPjRF5/9Nt2nDd73IBQgfS7fG9UxjtVQcEgoH6MPjJjXCqgDLfdtPXUErF2Ak3wRDFO93euZLeo2IBbFyCY0SEWJWSI3CoDDL1LsTrczG6CrGetZrPfQ4CEVl5+kisU0B1DzVtnxp9OU1HVohyW9u2j8z1E2ywZyZGZQT06Tk8UI8IQ6FHttGlb6+QQf+JaiI+IVJoIA23aBkcaao7xFe2+EHw0iKi73cJJyJm8ptN/ullHG6YRAW/jMzz0IVZWGXIMXApxNb97sRuR5dyEMwHQhCQ/gEMc6lxhHLzCgN/N1EFM1CyDWGCxHBMstZ4Oq9vS/vTXKYgW5n0wvZHQz0W1hqNYIU5K4NF1FP/i16Br642VafL3p5mM1mC8gR6kAgEjIO88NZ7ZgSqwAdHmqSIRYlCvbcOfMRMaR82+bdaBE/1PIay2ZcJNkUN7uMZrBxEpHRIKmo6BbnDJhxjIEhro9ukalmr49Mc3FCFZe4izQLM0iWL2HppL8nmvdgRN5T6PWZEscX1WdB0mZ0bpAnPZraTTjZgKx4m1+QA64vMdocbjr2Edc4p7iXFERLfOetjUG3zSwWvnlySGvWwmFn4NWPKqKIVtLHOTbmEsE/MvcdT2wgoUT4AI+vwiXSmMG6AqUW3O9KTFwlvpa1tQaYyvPIZV6qk3ymc/4okLO0fzfZEqVhw8gO1rgLDgnQ/wS7Mx2NaCoALcmIfOaoIm2yTC7WoMivS6QFR6CM7bk20o97+6hLLko5kL0iN1JeUypdapaPeweA6oRlIX8Gu7VEtwIVRi1jGONpY19qqqq7iOxf8OLWtgRTOr0OvOV16NZEDde5ZWiCIAPi9IL2rGUzuI8B1ZEdGzYN82f3C/umUQndAxu0zGU7sNRBZto0m/P1k3C2jcIYEYSUmNWkyk2ZGA2JQs4oL83R9aWcCqq7luHMYJEjRT2o1GWLTYHIZX9JiMpdgHshL7GbT2gxaJhoH/0dPy2DUORw+NUHe9Xk0+sD/cnWZ8BfWx3jsrfCFTZSnVw9Lp5OJ9JBFKlXmyoaV8poru3iGiLniXIpSQlng13uKeAER1aoYNQ/jFYGPpToZZtxo5yRyyh9tU+i8d6bzD1H9P/jmpO5n0bLCiV6pQJ3mf58FRYg6ztB9VuUXBrzYD9k/6ihfsVAc9v9gU/U07qlaWDmnHRF6MBnd2ZSM8xXh1+IGqHDEqd3vv9W6FANptVLl5ieqaRFdsBJzdT4/Y3AVCOFNlnKEFqdS00h5O8eh489YJjJcgg2OxWXuLbogbI12FcA76voD9UBAm/ncKwWo030Z/udacUHFXkKQz+aDY8Swzvpr678CoCKpzGBl9cl371kk4tBYSnXrIzCJCifzbkrRl69tNo6JPu8O4L3VvcLdrW8hjNPdLYYbs9NJDtazLTpRsYo4lMEYfPkSg1UsanhJiFar0kwqrSHVy39p2d5tOWKmM7j3Ue8m5VlTJgvz3NLyYoxY/AkNLUqTBCjj6rE5eTXaXru0g0MBQcKB5ptcmcuCeOMWOP/5FjuQFhhkBAXrOyPg/jj42f8NoZ8NnRARK7/4hSxASm21V0aMcyPLyoOoRUwZt357AkWhfabnS4a5XtFGfMdy43E7cStYx+7NBqFDir4E/Tma2xcYHCU3+Qf9Yv3ADNX+LdBKaw5umGfb4Sj2t9PKplBla68gG55e+z0M8xb+0iWlSeKJWrzw3V+lPzlL3wL2WND4FQ0yq4X+Wyv2To7tlF5pd1HFzBsfIzEYDDVGpdG5AVHrJz4Sx1sNqVBdiNB0htXx6ed4qROMi9vgzPXxDrDWJwEoZzwtHxXfCRfKVvgPxoZ+/449BTlbZvs+tUGqn1DFB8Nz/a19FRhdlm/h30+PBdPLI28ZoZ302Gbn+FkLNTz7FdhGpGsFWmckIQkjDHF6/3y9fZCypWsApMJ9f/RKF6ieSQAC4ZLtcPlX9j15b1/rlRl2BrPjsDNhhXtjQB9RMhahe4zf8bnoHC90sBeRrIealDhTdxC8dzPaztkX1WA5Q/sJhRolhtt43UVV1eSiwousy0p2tr07BMapOfxa3dixMBsK9JM6GfDO/ejvH9TyK3zzL3BT4m/7cGW8qHyqTapK/qAkhZVmSiNQA9BB3+Ma4VoxjUGvox8z1sLJoOuEZwC9sDdDjJ1Ve3sGHlddD7q20kz9mmlb1j8ODGrWrCT10z33hl0Ov2YCAmIKRqK1YP8FzTAm4a7JxSVsHVhI38K9qhEkPQGo/2mcXqgvwAlj0nLfhcFN5vHFN3qoy158cfcLpKrI2iS4F/Rdv9G4GEzYx8zoFLxTMkWvCS0y51Wf4aPZ3jY6VqeViTcFolR8rs/MdkLTsprArAGDDfoOLU1IsWgLWe+vhjBdd199s3RExjsNslnjM8lGRMEmpp52jSFBYyRhMk26j7U816hsYNoXlbyWy+Hy++/YqDx4e0e1ag3I1hbXrA9p9vmEtwlvqsqYCu8oNzmjdslaIPPlMfztY7lb2X7mMOCTSmRpkwS1ue7atfAcne+a4VweftGGos9oPh/6EdfDU4uEVMWQZ2IwDOoa05ONx4xX+jcTeOB6XkMS6yCm+eb55ft7IOYVifMyqJ2Q1mMj3AA23Isn4Q9nRTriAeSfdGtgmST1KDVAqqdnJWIT3FCbdIBKQldX6/+nm3yNqZsYTZtjfTTpYPw23JrqNgeG0w8VUzN5aHKdJ6QdqUwEkEWLTiNAi6bT2CKHN37LScMcmoEwEcjCf5oRum2hT5MhTDOZiaI7deGohm9xnNnJQcGlPFp4jC0Ity/96rrHLgw28OCUVg6TC0F5m9x3Fj4JSLgIc21aO2KVnlvJk06u4aT96DMEp0z3i7YZv44c5nd7PTJ0KoReHDYbHC+SscTIihh4xJRsMxF0SulLgzg/V5X6EeHWFqdUFgMnPZKP1K543MUP4NHL2+gnm9b+dG0v9ppBSKtSoYb7JMRrfyVsKjlbJHrSMZTupFm+OZtcqpCZm8ya1vpDIirtfklUpkbbf2BzikrqbtjNVLT1/JUWOaqcoWg1A6WXEOTP3UYdmRiTEGs1BwxZl30MgnZI1x5Hj+JD/8s0O8hn1rjFxdRTKMzD/wKtjqMFjBO1anU+7TZGC5a9d5h8ZYn3e0+pCnGXdDjPTQL68Awb3T54w//bOM60PpygAd1Rox0E7SvQku/ChDqWlU6YAFKed4B88DwoCbFVCsRXP7SnJ0HI3q1kp44rpLITsJXIa8RmjBuH6XgFQ9bF6cMtWuU5Pkm3ZEowuFJdk4EIvOeXsB5+5zYC3DnsGIlkCYyN4mKbjVSIfS6ciOOb/FxCT3m0skCmVgQa0abF7ByhTLbZyUa+j6XwSyudGEpomniNNn4WKHJNScPCt3ttud+SyqLOD/JTRs0Jds+l1m9NwZ3OimW0WNzC+0pb7RLnsAFJlnsQQEJaeVb+RUABAR94/HKefl1ofeftJc04Dxnkcu7wRduBfjy5YkA46aajYYIAFHgnJh1rnt0MfxPr+s9zigvWx2Pr0pMY4SCzFTnMv/tckxE6KT4eyym/tgVYnzydHNv1tJzfYLK6n+g9gh25ADq00dGgHJBg0zsGR3AUUKf3vH6fTyaqs9bh0jZOzIlw5KrahAJHoiUeLmYD83vgiig6b9QdQpmQkzYEGW5Vht7ByVU78S41o1tBjkIxnWtghC5W7k9gIoyAsyvcD4SohIvPh09BoMQIWFeGwfhlwoldDHQgTvAIac7Yfj9h/RRmOZqINQebW4PksBjsA2QUlnSLDVQgr8PGlk95skjXAUMSm5fsUcG0w79gu6pHAWxtVYWrl2mZ7hN7hbo5i5H7cpRBX6ZvMyi/57MhtOkrH8Vjv3ZgkpbMUKyIuHuyurtjpP7GBbZ0dP1fGa1+lqeDUKL0vd2N8KtsNiNMusT+Wk84GzCm058WN6IETHeSNfsNl1qZH4IeYp7x5mVcjUNo6WGfqaOeTeV3u45mkHdXhhk9tXwUdDsArlPV9+9yLfeoOsHyPJrV7+5HX3KHsegu4EVHmL/DmxrXBByqdaO5tEm28TLoHr59uv3nKfdgo6So1zkuZ7jLPzyg6EcG+pFDsj+Ovf5dBXf2C57lFv40nj6mjVCujmRL3tAKaw5A5opzxi1QV20EckMJTCZqOqAgN3ULDAo60fsgTrmFw8IrAqkIIY4LEY1G+ofHC4Ij8IPgXZoxiGbfJLdBRPrbWebIZcJkYkbG54f+HjPesS7T+ICWz2x8BMo80vGL//B4du/Kq5Lic72qxJBcDKxRUW6HILiAMRxgc0lq8hpc6P8qGe/e+WHpb86v0n7gYRFwnrnCbONeywvDvgCA7OAv6yn/bHoALzBVQAP207CfFD0TDs4PwIumdpOBSbjutA4Ib9eMhT+r2P0hHOutRFzfiRDXMObdrdPdL4+++Ij2JGbwYNN+f6RnNLsieV73dh6UP7tKlKZnaTnVtblXJz051mVHx2/0tcTKaw6LX28vh3FXBIwGz/F9RO9I12rWFf3zTY6bBDepTOGAZSNXJd6KW9c/evQEgcdi4AF/ChxMe1hU8ZAGo4d9RI73wJO6bteSzG0Llemj4+/Vt966SkAB23VcIxobNVxqkArzNsP/L2OmE04VFlym4Tes+L9V4MAGeG10vYUwB5BwtW2T87GEMOg7MC01EFVEnzxVAgUphQ9U7gx9Dzyo75XuM2+X/di55Og3Maitgka9VuTDKTbzDoeUdLutlQa3fswVvel9Gz3mdRrD29iJVHsi2DhtecKju6/tGZixwTey2owN7UGt4/dVkpIBfkk9I1qkNfjM7JtBQvlaI47vt+0s9rYPqx6liSxHaOSC8DMtNAdoQ67OSbraKOXCUshADIjXQTIoaOC/ctrOfvRuW8VvSEuSU8l8ilCJqstSuCMMAVyz/kn3dezP478G81Kb68vare37rcgmRyP1nCmXv8KFuru0jSdyofQ1gr89GYWhVZubr7GhRyPAFgPZ2EBbTNTvwh6mYSHSWZeztxe+hX6IYRApjFHZJPchaIDwvEAajxf4DLaREXobe53vKTKoh8v5Ax90nFbsZ1hHpBFIM60LsJhAe0DXICx7AbqfJkzFXEMAn9eIgxn6JctyKuSMUPrb7YvWw8qvtQmSXPgqfJ/IGpGxyMseCmqDLtUP37i2TQOrDqLHcxF4VOGc1roGOF+I5iGQq2e961vsX0oQGTNv2gmm6FPOH6TC5lhvlqMaq5iLi+xy8m4mA28n72wd28PA2wOYOEHqe6c91trWSMOuUdctgNuo3kLeXrWhL050FN15JzYi97cxTUPPhj/OKJgQZULMS4RxufUkQfUBpksK0w4edjLkKrVc4zGCg50ohrki5jz2ibOD3Tsltw0mfZ/EAl5HIcImFVtLJh7PXNi0dRCqTskdAEWcXeGI4946S+koZWrwvOgbLUzfcxrWZ69lQxymknWgY1XFlY8CycBVWTGGzpKTIMiFPQW+MGmY8v+wIoNBpM2vJNh23oMovdpMVJRtYJB9fBgEpTjkJq6mk1Zs46Wvl0KBCQ0Ofa/0889bx/XnBaA0TzBmABrAnjRvopetuQyGRpSCfpm8c6ruL8ybgTi8qLlDh0Z9ds5ESxuGxp2MkFO0ZDt9YPos+LhICw+P5YfyUvAMbeNlaxKLHewn4gAfeE1UVPv3xs7xeiNPC8t3BWY/8KJlQtIXf+IDGEDx8EH6p1ZdELpqpqdFFpBfjYKLbR/FfhBEQnVvYIqMypsC3TLCQioULiJnTQRDxE9E2GXMEK0GdJvyD9B/imMa1X8v9YVpnmKZiX95NNAquLk/S+5gbRumzWLXG5VtsIMqZbnWcT4hRkeNthnLjo5m19s2uH03X7bJHpvd4BEKhgtdNVZbrkA1oCvQkxBX6emgpHYKuFPW+8oZRj3RSUvNtiiiFOwT9cm2BBMPpT4tpSL7KSCmAzUReeR4JtCFqwXwxIFTBpf+4vAVqsU9UZz/ToqCKiyE3qPVjB8cUfkdSY1jhDL1oTbYxQ99T0mx83xIvopN3/M8QFp4c4PHiCPE8+pGfJog41udEMfBtZIbvqfwZvfws1Sp38NLD/WWGEJr/WPVkcTGq+N3P6dvRZw64W2AjXfl48hXP3sHkYKvPiTiac8elp/AoNwJt6CVjjt/9ILXOqDu9P3eXO1PujBr0flAKM/6uAohT4YnjSHYzruaKxnMhQLOej4vGmxx7Pw67/ldDGp5tQSTsiKAY5o00FQlLWRoDqlzjmVV4qirw3P7MeguuOVvlJN4ZSN/eNWszCFNzKZc4WKR8PLGhvGQsMeiS5T4X6hd4fO1k0eg2Uk4qtAE0qbn7FLwOmKSdi0mAWJFyoTA2++WUUFK+TRuNwtcMp6JXpunZPV8N1PN7PsKs7UUDTF2Pk4w0IPDjEhyMNL0qGgfCS99xkj3vfBNvk74j7XjdslZnshnQpiBvqpt32UiyQ0tqzGYwtum7Ijm+gSH/nuRAuRFGN4TFrDvMkFhBqD92n2UocoUdCnyW1pr7x8w6S6Mqr8GMF8hwKmB07NM/aEHDcK/cstao9YzCadLRKD+vHz9n3c93u55gnVFbQT3sOL+PO/29bP82fPWsVrUBlJztBJR57zqtNbmI68HNVvHv9CIEG0RIB4YLiJOpjCSXN/xcTrOE4K7i/qZ7sJ71wo4SLcSMjmbLGJnjz9nKeFr8688CgZQV1C16BqZmrX6ZuNtUgeMs+rdETGKIv+av05Pm0u2qto4FETGaIkDnljPJDw/LCKWN2iyXqskZnON3b6OashyhndRrr7n0DiPCHG/leh5SFA44fOCSWaWeyFhxZKvMRkBXcKMqZpDs6akTeZTVQHKQ8a5CxZ1rbRzkGBRqA/aeWgojzk0kgQ000nm/OuAOPrpyt/vachFhL3gq9XVxHpdRaq8cOkKM8C5MMsRa3VKMWs2XssZLiV7rB4YvEFR3DylaUqA/AOCv50cqozJq36etmk2SO8fMMdwGQ1RIQLbnWt+vsbLz/yO6gfKTAL8WI/KXZepPj7ebONXSEV39BQBmTad7Ulj5af3V5bHoPNPDjFn1LnCIX0fneB0YwJrvr9sOyDSMrRsTTSGN5NLI/4JcUxIMfd9jYD2SFfANE/srYNwEV5wWb64sW540aRM7GORGA/HGSHlyZVNaAI6vEdIz2BO0YlzkS7hgtFlkHwhSSW6Ax2vZBlznNvuKziBhcFHxgXeWxT/2ixIpbguT5hGQ27FwAPfubzMnDOXzFOQJ8CbX9/vnvPbuANAB4QgkYQj+C/gCnQGlsgVz7Ns+N0Twv88rGae1c6c4go/gu2a6fK8uvFmodi7cXVp+NZi4CeHN7WpFMstmbmnH17OQ2K8f4emnygSauSuTB/Nw/xp+IaTic1spi56aCU+9xl+qTGDw3J6RA/zZA9SJawxhxXkeMj0WSIQ+n7joi9DSE5CRN9Nl5/ImyuywCOpyIT65BwPsUjjrw9CxVKl3CJmxBuUHQELJgQqYcaAYMlGPxNh66qYI5+xGjpCs8Q5eAo6Kh17FNlLgb0QhBXwfPXHZwZy7wD62dFjNh27tfyKWvpg3aJajZjCgef+7UBYPhoPlKWI3j6TTesMp0T6a4RltN69YFEDb3T60Qzgdo/zXjf3E/fEaBE+H0u/I3FTIT9q8J6FKeM3FvYx8sGT8iSBk/nrzbaW4ESJJfvfXmOmDV5SN4MpAnmvxnsnXiWaCP0Kc9soQxVkCzuQD8u09f8jGSHpZ5P9QGz4ZNFKwDpQ5r+YE2gXoYNWXhUsssqqFlS6k2Z9abohY9mEkDoH6zfq4kBCxeYXa9Yn30Y5qJ1i5DklhPhJOp+np1FhBkRkXtWfeCoebk0qXmAoK2LDGUx5tZvsPYdm1jXKOIBKhQcFALksFhQZvsRwQ2eu0AKIew8wN4o0mQBmfqfY+Ru2SJrwkuyRgbveOYNM3gGh8HJAdHsidSpk4gyK5JADSHIfo9oXeX/dlGkmrXMXjG0nVYGupkTv8t9rb8Q9izwxaWWNBXsZZW0tyQCe0qVX89NllLdtHjXMM7l31EDnZEV8u99+T7X/89ighLhiQUMZJ/so20eghbruPD0froUpJPo6GiBfb6znGXEspGCC++mRSCNKX14U/EsoorzT+fGbR1Cn/HOstkhxqbMbV+ddb0+KkzCdILu4WhlsIfbpJbMtqjkzOlJOt2Gi+6ANejmWStLlxLoGkIBqzHX5yxx+H8NcOH1Ti5/WZmcNKi6+PDrYj8q3etD58/5Z31ho/cWcwrqMG+/kdMdSMpQgO69VmLRKO8gUC2a33T+Wr8ItTGqaIc0cBI4ue3b6cMa8rAQMPp6XWmthQnX5yUhw/WKiYZpo/ypYpxl2Fox1eckxV6crYtJP+d+LJnapt10XUKzpJLNER6e39hzcDzLdoETUXuxZgAYpN1cGjmFh7hMMHTMZfi12ki22KvvML6DQeBRNcu5riervjJZ09sC42SsR2rxRH3tyucByNH7cxH+o0Nxponssx6cGAoGKAWVOj/HiIxGVs8MJN2amwTtZTUy8pv2jWiQYcPTS8t8ElN/0o8eJd/mwErOfdfXN3mrj/Y/pXEcuxwfsXPzrYJgPB1CEkMvBcqB3Zccpg7fYiPTO2uiERyQ4h4C5VwOjdmiYZ4CgquPPgFhgrwp6sQ16TvLYN+ygEukb5aX8ewG2sTLFQjicQwipOPM3NB+yuEm6ym4uimXVgVaDh41uuta6GkW4sGD5nuwgOSyX6rN7lkPhuZK3xCXe2pdnb2JrBoYxyQQQWnrodjTHjfpW9WUNtKRxLTOjMxFDFqZ9RLaq7W6Pp+KxOL8kQWMpkYyLct0ZrU+k7bhsuTFdtN9PmVoP5/dXb33sDscTbJQVXH31XwBwp9N7PKA8uY4Ffc4LW0N5wlK6Oge4RsLApaGUawfH2AHRs0Q9UTXxWlNKq31axqD9EitC+ySnjX3iyoMnQmyNQjE5Mw2Ft8Yqt80sIsucL3Mxopo7++bmPrPQFLa0IiPxcoSAZcmnoAY35ZH7+4mKLk54TSvaszqYlOqjKO3P4lNlOLFYu+AY3/XfyKane1YHZV4abwzhafwmHzOv+Pk9JU2ghAMe9knU2XTtXVgqrRJXpXUKTTe8D61+KID22nmEFsjAbAXtxTLxrYDtmTyf92oq4MxgbpzhvlQKPr2ZmGJUm3LGzt7uqCazhtOFo78Q+Edt0bfkOJRGxCnaFtMPZvQr6BlPPgiJpWgqkHUm6TcXStbOYvXQfCPv+6j4FZ0uuJtTMHAWZ+6RWJcUUeiGj+wd10Sig5ue62nMLHvFUvdZ5adbjneq2AQ7c2E/09ASBPuh0BmOmR0GqWtvhXIMwCSa59UfySRO3X2otJJK/6DZqBUln+Np+hofPNDVkKphfB7egPPZcOEyuiySwjlqPoKq06sUy+Kl+b8EU6F0eyHuVoyB1RGHweEcT1eyQptsp7Ue2hP9xFJ/q7NF+lxiMA8hlfC3Q7H6z96EbTE9s4IU71+zqqIPRX+iO65xmtdPtj2apnctiZC0UoRW1L07XnYQX5Pn+oc1fzSUFqt2fK1jPrhLDT3wDKMyegHN3RdTEXc2YSqhZ13qRT4xL3skHfL4gmo0NC7+CaHYpp96koW2wZGJZ5Yfd79uNI6ZKMAz9vyaFOdb6rE/bQH3hxUJz6FIbuGxgXBuoJLbdxIkmDioL6xA5lxTt+Z0IO3LeX1qkTEzp3RUY6EzhHCS+BgpxxL4QRSEbFvkzEJatHIVHtwzyJUuysoIIOWFvPJ4CoVDtIF5JgLs7s3KyaiPf0rVhu0sdQHsk6Xf9p2q1AH3G3NR0Pi5kIKtXJS7ZMaMzp/1z2RkgEGaMZhNxRBSK4RoaXAADgovGEjUnmidVhLh1zChd7zD55WI0gBgRWgjd3yJ/FHmmzBKQsmKcvNPWi/ZQvQXsIjtYMDVxcOKbUTgPThore8Py4RiCImTFvTStisw2/rRabr5vIHh9XM4xSvZ6wK2hyZHWHrnkt42vIAwDIPZrxL0CQMJiKgIN6d+wGRTvdSlo/Sr67cqbF79BDb6NR67Vdpdt+Ek59b5eMAntS0dpZ0+uFeCHoqzS3JyTwyZvNjDt0Kpk5POFcu0K860zR9MDD3WzAjDL0edCc5zHEIw7M4qJcOZBbG7dcwLPTzGTBIIRBRhnbmeDqLLdiHXhu5DJbZoV2jVjkJkrAZatan30JJy32zwzDAg7WDbysn6z0vq3EfiVdwwnmA4hj/yMdBWLiTqilu9rbzQPe7LIPcc+eDhm0mJK50eE+QOMzbNsAS9SQo79CXhG16pm32gkLIt3AvJ4NQPsvmClb2iVHZLM7bOCwiawTyibVoBEqMZ1xpGZE4FTJlhCblKksH7iMkfNlasTvx2InvLbA99zOpP1VKFm2FqK8pTS7xZJzGYLdo27ELT+myWDAk1hjFsiN64A6Q15Pcu9Xed/SY8sTQcIkPYHg/tizRnExkeuYoqtJ/jjRnnQzk1uq9Cos7wPvEBW+FEfyvS+Oc+u1uMqMpbzzqDndWdnm0NJRxn8MNDpDi9HUMxIBYwAbht9DY9mxkFv6FPFuNp90rrmobIFUdxxJUpvBmDpS/0KPN/CIse3vB7AYH0DEn0hiohm9EeqwZNUiInxANCAAzIsivSw/smsX9OToNsOypamvQZR8m2uIIdRNTWX0PpZexuQTnNKJodsmvrJl6aTdtIfVewv6+nD451yh4EQYxAvPnW3Z+LJmefrXYulRy9c0nUpGU7zcZFR/j0+68w3VXOAagM1Z8bj9J2wqb1lInxrMnnm0Ynd2aNHxuc1gCiqRtyYqfuBqX0/VpeiIIv0/KK4ZTuf16sZ4BKbXxUpRH7UcR38nqqtKH4IJmyOYKXV74Y8SijJLhQ2EGRbIDzxVaEYdaooAwM93vd080HmzLotwo+Auw/FiOgo2+OZqWgQrVH1Vye47rcGKRq0CNM8CBiFcWS2QGHl8GAB3uoLI4LkQt3gCGWuFNCNAxY49aQwUxB5iPWLqKcBjWXRQr/C0SzThIlmoNrUWjcPU+/fVtDWz3yN1LIHTiI8c8Wtmb1n7AwqE6/fmm7FLF4ENavPG9w6nAlJfd/96JnKVa0iHsrPztJ3L4T30hS56F04wHVSW3Dr0BWA1aiUpxHXJvoAdTxB6lgz32zmE/iLd35xrn4wWqoCWiZcMKIqFwQPup4IBF7KJr1fzP4VmBty5eXpiLDVKolFlDDLT6oASJ8dHa+rqzExla8tqgCkSa619sJDjIM5FISDUUscJrHnm9Q7GzSncFPswmRJSBgJges6Tg9PQdIgkw1KwEs0WF+xoB3UxUzW1B6ao08/fVUcNfH65pM2QYXCquxU6W8fT+xbBMMiyGFhBAwMdWg2Q5xUds5szkzxP9qg+avh71TW0X6DZOtr+xD4/Ybb8qqzDgAv32qPAk7h2Zhs3GLob5FG41Cng89iDYu+mz9KFzCWHOahf96lqaPrkl2iG5a2WcXTN8rxxVHiu8+e7Oboan1hJreUvB6FqoxPQpfSLRLvC6wryxX0BZMXYGJ1pvleGrpHpPOaWfFIPL64Snmg2t9AMZux2pa3q8hbq0eYWbQeM396Ps/HZ/MO0Ux+BhtfCuaC5/axV3ssaltyqM+TWYwQbolrkUvn24L32jBUXhBURLtRPVPMBgIDsz8D5nd/nyewIcSIQLm1V3jPBorI6WXU1bpEwVG8ndPP2asiSG23v2V+2LcJGaWVFyHnO2abMgidjFIPaN8oeVqCE//r1b6zWvGXbim2oTaUCR/ftoD+uzP8XbUU0oGwU40nk1Pzr+MhWYmuopmd0xXrerzY9Y1z+LRsJZAU9pwIBzfxlw+agGhlSmorkD0tgz6oh+hixqI3gnHCEDFWOC6aoRXS+IYFUZ58f+NUAz3OyWkHGO3th8kNBtujmqW2/GDQHuamCKphdFLAcz1qF8JO8F0Tm6tJVYV5eWhqcWH241HF/hzsed5YQougue5lr8cT+SmtNEMjnF03r6VNIDICqYYBv/Xp1I9gDwwyX1Pq57gz5WunI9hPUwczLJ45xVr9o032bmazZGyIHEdCxaDD1rIOYsb4+etHu2GkYcn//BNa+pRb6fzcOdNnCZa3KTJQUfojNBl+KWPKdzEkguq+ZkpQp3O/ux3EWui1V8Jj5HKNwVQQetENRRGnZS6yxuGe/gD6Gyohqg9Mqaa1cLVptReynIMmtxwf/Ep85Whj0EpYq+dRlowjxaQDMq67fxqWbh37UZE5ePH9e5s0vh8Ba7N2jgsdEvliz3505IZBguHEPeHP/l8gRE94C3QrqsS9JoEN+u+BNud2rWBfe4oCUegOTqyeEnA2GKvgJFJPF0Vrg9NDXM8TGq9tHfiHhM0+SIS1w78lM8Zo4zx7oEm5+cCPYkS8f1O4rDR6DLHIRFywnP188yYCLNStTX4Xg0MVuiqmNfoI92yPIAmxA0AvKDMKEmE/2blRExO5jcQ/H1YKqfgtyNOV4pTrlar51yFmN7OyMMI6u+G8RsjXmplOMlxOBbD7mgZkhtPerB3L4nhm8AKdUwCeJee5VoB8LkrwbhorU43uAf5RQZyM9bM5SsSWqqrS/BabgIzbrXzOSYXSa2a1pRssiOJknSZXLZe3H4ZDdgQgoox1oETm70Sid0DSCwZ3O4U7ZgIOAXCworwY8ZB6kcrlvBwCV6CUSBuhvEyGTqgJUOqdoEmdq4eLnGA8iKn0de7ExhFaeNDFJkM+jwfYxv4H/WNOh8a34YnFOR/oDN2x4Pv+OB0rpmMeVNqF0FJJdMpAViZc0HGLqNFGQakU5dZauuYaW85wIwD5dwCfrh/6IunR2mJhiVvS8tfJiE0hRmuoADRf2tPPUfFZ1mxeWTCV3UunNB+UmZu7AQcGHE2MoEAUpvZzZ5pP0C/nqsP8mJTLCuEBo/O5G8MFAuVXP7Ef/Bnj+ZaagrRrrnGErB5anxmWEvp39l0b9YHVbSY21/XzkwEizxGYaxvgiNoMO+HbW7nkaB2difcCaFi4B0bfvWwhvtkm831hm694sb46nJAfs4CBLifnn/HxWHl8O9MzZ1ZkoQAdbhws6gizhf3qO4JhsKQ7LtfjmcvsopiOZn0N4FCWq/Yyx/GIXZVEAEop88wEVE71AwkxVRN5ODE73USggkZ8L+RWmbAM8y2Jmv9cqtPzx6cAPYQ30IoPv7Uh8O4wrilxOX+58MZIGzpfB1eTNVcR5N7a7VP6XksbhGLW3wAdlb821lqX03xgZkZx3Xcow7UGr9TqmdAs3sn1MykjGp7IJrggnq9TV7MUks29oU6bKvn5pZc83shkc1zbgut9mLoCzkFORrQlE7QiBDlC3RyHEFce3oRkTlfEFTsGHQFZQRteAnffeRzG9ZD992R6at4c13zggKJvNcpQ+8kJfpfZAtJhf+azufxt9HH90Go1D9qPECQimBKgDM69LcxT7+URx1dVv1OZZPt3JT+a48shGfkDx7rJAjC2ceP1lO9bs6xBIevm/W9qIYOmgV0QuO7Mw95kX318hmDB+SfZ/CKUxXgV2Nw5rO9PllGLgUT3d2GgFaVjVLEaSHRMAk2CtnDe5EQuUn3kCskZDT8zu31bzvfKq5dNO6STl3xTdTgXukLUSOS+xs/EXF2b1kgBkigm4VW6eILsAvQuwVOeH4G8/n0WRQYdqIsnL84NAO/EW7ZqbnmuCH4R79PonE59voD6CZ41XFuaH2QkE80DtFfPSElEQwgqNKnh0NzM4Cq1IKxs9XsrYzc173UlUUb9MZN9dNbthhzcg9FyAETL2rIyDIHmhCsJMtI/GnNjFXh0XwV6CG06oHUjd4kSdfBD2lErua/XZmPfTZIIHV/3SVagMwRBmYzHB+1akDfYO4xjDj6UhfWroflpu2IoXuIX2xN5gM9o0rcSc6aGJqIzMDzx4AHogJ682SgRN+FoaWzC4Lgxl4dIhq6LTaj0QaFDOWZcYctFYxATbNMCTtggIaSuq8iyFaUgvPY6obpRAZ/OW0kEz7WDJ1w3ai1H8AqS+d9wwyu3NJzNcvH5undmpygSEELbi1o1Bo9Rs6m+rPR41yxwSzR2YOStjYSojZdGvKG2PTjkz3iDgKWnshPWO+n5zcQoUUQJOnflmmiFp/0USgrIL0X4hNZFmf88Rtq0Oo87MprGiR0eqRnEpvvPNdpqXtuvV3DPTqDQbnU4ISdywOHRWQnAfPizc/IiLm1+op4cmHoOx+u0Feg94AfXmvF+xyNmXzgrYdyAS+W/jQ8yK92Sn5xSRNkf4uKgutYvVlGUY6V0Mu+6GWFCr/S+cQIaHtduMPjs5oJbRS4clD5shyiLMln/f3f6nWR+l0SsX5zxFDhBZVjawY7iJp1eprkHEPBBUGGGkAr6E1evUB1N8nG/jCqXGdbj+FbePaqOxe0XUBHTlC3ChSwZ4rID092aL30QV/yCWKpLx70FgN/W+U6I27TlE2Ofmz8gJExx6It7Ouv7ptyNsG9PsajPUll9MmP3/bz/qBs+kdplu8+S8zupmCHc/QBXZf4l9WhiKaXyvL+sGkJ7wdbnaWkhucfsKSZBBt2Vq9f49fAs5mZbLKzibHYEgJq8R/rBRV4p1M7w4mlTRy0wxwYdLMSPxmJFmVcqyBBO+3WM21rPjJKqa1zZZ0yyPRAy0eNHvHlWkIUhx1n5Jcv3pTIJg2llVL9KZ7hS1RA+SSEkxdPkDg//twPbiI+MiAZ7snRba+xzRYXx2P3DiRwrgjYEwo/FHD5QohjsGPJixDloTlZLVD3LsTfcYnMZCknLHHv+WQ+ZRYv5fam5DaxxbO1BGUiizg5r4DcHx10dUAQ2ynfPxN7krUIKnAALhZWx3+Tp1vxcWpEUb9OFcvXNTaACK2rMyi86paWZCHhHX9d0xFxLSjqS4bPfH7JrCI+O4tnFemQENoOqkBhTHOO0UFkJY259G00t3fCgPDjaMQeEAlQIpAEauuEMjeNv90YRhHJ0rcrBi5YQFSO/ZZLKX2yIWryyBBLYYrP85wbBCsAw/koEnCE4hBcCDq5ejVRLdetJHF2w2y/RlP1Tai8wd2t8gEkUCI5OO3pP6eLijSMRBmqBUefShwAVxuPkRYlbb3RS/u0ubVkKTQ++FD7hOxq5m6ee0m1KPq0855YSXvOsQ0g0k/oP6TTLOWqlQEf+Yt33WJVxR6TLiQ/DzLpTAyqYvZkerIcKscJ8e4z+0fEF1CAdY15Xb6sf89CSMBWbnHDg3EywlSTb86Daw5gGk61JNGyKGfxBRdMH02kmXb42uRc/R2sgh5PVGhlVTEjiywWsRowEeskIXFhoNHjEg7kKbYRNIGGjcIZaY1bnY18xqF50t5G1rn0b802fSdVgSaVkY3o9qV/yJZUpKEnG+t9Dxuv0sDiDnmP2PdeECuvC1q8iO0d2xiXvcrAGoiMfWcCafnS5iwOGxkHLTMWqNHbJp65L5Vh8nyKTkWDYGAIlfNmyGwd4qB+j2nZIFjhAyBmTpTib2OcYDVsK0nsJdUhjfsNJJ/6mIetBwlJmrY+rsNWqEKbWXng72ZCWlD2xCqkK4CE5XdKu0P+6qqQNqU/xw4xqDTfFWVNvtmJWes9NpwMMqs8PiKK8va6LXd3LUa34euP7nV6E0DZgkjgwz5UVm6bRnCq6KkVjCIZcMBYltKK0Xfq5Wbdi+0peWV2pN1502opbUA36TufrgNTtuhTBq7iU5l/KZcBB/BAsJ6QtpthOoYBMYXyraquMLvKjgNkEDrU0NJ/37jzr/PODx7SuG51mheo7ytyceE9UDnmSQPbeS6dQqw6CRELsf0nLg2gdAjTU7Y2ruQZdvUlR5W30qHvSIk1erFy/h7NKIysDnDN/i1Q16ea7xqMiEG4S/ZzRwtWVriIHM9WN12mUpQp4qQoFdT32g7TtEwh/PfFSJL9XDolg35gyRKQRwFps5q7S1p51Uxdl5/X7VUYougy9nxBvgj2KllqX2r2+nHlkGragPBmQsbiRMPxCX98h1q6wO5olFVf/wbSYuBY3HDaFEqQ3PYrfuuUSsYgFQxIbQmFpUvXaX+DgulcNDn1s446/32X0hwI1elsZFBpf3nYWMWBte4Z7kdpxPAfUQnCTY7PyjOKiAz6FMc8Ps3wohs3qqafKkzmleTk+NenzQzUuJek+0pnGMGL84zmJ23oei4DUnm25aQlRPAF8dJ8ZS9V82ixCbAnsgD9XjirNuQ+0yjJtxXOKS/190AsqI01O2NRsjpWs5UVwq8cGtPZbgouMhSpP3+v+YoVJziwJtFk2ww0GB5Lo3dlh+mH43WevIRXTmYvLTfXwa5PDARqpYccYWPcUK1fjyHqnFz4azlzMw4Rik9uz5UKfdY1tav6yZWcyXtGBYjax7FKwF2E7oFHJrgisnrgOVPG5wTpyPLaTws2kDVo/Qg1g8jFxcSrhf72mfXYLWuMUy9LfBPS3tN9jMjosjcuLwGlfQ7Y7iFhZ1oGbCR1X/FuDq27YUUWB02snbR6aYiuUZjPh8ErXt+rqxnhQ235FqoYUFBrM9Ersnjzsq7OJRdcIfG8MEbtcZUc+MvI9bNVpAkHf27cijJMiVSo4Ullv2gEIdW6SnG5fup1TPHKFU1b13PJSuHtlEzj3Vpe/3ZVfKvyDQwCqQb0v51CbuFswGNImrZKxMiibgceAKFGoL/BVkDcsIt9dJUK+YmGC/Lub+62k+/X1NHn7Ei3u+tHR74uFryNBl6rx4c4ryN3jpdgCVNb/mXza6gT2kvq8N09WDmlSKOYpMVgm7ygLYwV52Q5zKWrp5+/U6kPgkD2fKhjfuVgN9RKnEMmbSH9Ure12z8McfZNr7qQ07rISLcUElaElK/yl1N4MMGxhd2Y/ZZIdaCsjKON8pBiPmLmQ5+T1G0GzZ1k8gdIEddPi9vNO4KYY+Vr3q8vy0kfL10aY+tASJWIRIUYBkfAJeGi1LrlIETbvCpCOrxbdxE6Fvv7EfwAz1/8mieLkPUONPofD/CuZzgNHEjYsmEgpCMaBE/eqAve7RDxzkuHMAQubWGf8AP6HGkwcdbPLVOyl94Hq/I4PwrbId8+l7FWrIR7ojV1ZCmnuOXVKrNCv/BV5KUnmOG0YSO8UV4WkM0ZZ4UvdCoL0od1DJN+8QBvp6TUhjP8VytMVzNYN9N1kLe9PzCSz4W6YHVDM1ywv6TM0e01tzzt91D9yIrZ643h4BL1+NKIOSWum09HfacLh78XruDkxX2QwsVjJqHHOoc362l9ZK49Uo7154VFmxusSxt2GTjp10JVfH7P44KngBngY39jQz79LKffD2LZyjz4hFiJEjqY/CHLH7yYj5DMU467LSLpaM4NtAfFSpGeQTrAvsvSS7ue3WveFSiEe67HJcT/BqQNJ70Un6EpE/8VTq8yR1AZltcScf32QxqqNTqIzNQCBLZosdE1TkKCwNnxt/nnWcipTPUspnZf5PhOkfC/BPHk1NsnzE7wHvKv6aFFgUtEGhg/fVyvc0Ru6NImXl96t86E0pGXdS4YM56IBDvY7w9hnoxSeGNPvIDu66Mr3KFi75kxYZEE6ezM9EZ80llEUlzyhVtAoSkg94RQorYRJmZ+lVIrO8ijuIDi4KFwfhKnJ1PiCZy2uSapxCGPb5jrk1WscHdmhecxlBrh5/37/FZJAPUp54jEldTC35TG5UZ6ubWw4hPd+yuUbZ5b+xyK3ZlyH9myCB+uRv4cLiTKPc/UebYT9bC8kbIgGn84nZ4tcggk0CGELTaeOBX9rQB985fISMW0Sck+gpF7hpVGALxNgrMji4YnMfiA0xKpn+/o6cJ/hPSTXANneqxJk//7buxlrZdBepgDlK2gZ7L1Fwe28sJzMMwbvjramMkMlfOoqccw2Jm87J4r41Vn3FwxX5sK7YacutEH+Bct5ijZc8Hs1t9tbHDwU7naixYrBbB76dPiNGalJ3H+nuhhx1L6wtGWJ0Q05cn5ww4TdeZxeEkwbrAaHuX/ZiLUCDRqPie8Devr+EzBWzKG9hYR/nNmbpZyL19LrkKXB+rxTHzcUwl0IYGwJQBk3aFvfVuvHZY7RfoEux9fDOZUiC2COJQy+3kBJ5wgyyzQZb8wefp8PC14hufQ3ngPU9AAR1BEopmMF9/b8RnIDZ/7mXtMQzncFa72Uv0OdiISFkC7iuqFcV19WGV6EumJnR/DXe1WoWOx2Y1gE2+PS5aFo9/vX3rl5LHmiGNpJVP2aQDa1iPSQuuYX101EwBy0n1MqupbitEH9zd3BcUAgmV9kFAM/ECah6/HpdyE0+6ZwZ0gTlJJdz0lNZcIdvD+Bw9Jlo5CXcD74eRiB3h50pWRSmNBOYiDnUyiNoBW2sgEEXVBI9H4qPc0a1g10OJAel3R/vagJI1TQqjtAjXnpEsc4xARn9wdCbG06WB/+FcvYQE+n0ZK17LmUZCj6s2jMQpD1jW4hZ84yTmpmeG7/6qFpWKhvxAMloxCvwv6VQNkwoxmvU5qh4+ZCvXFCtydwlSKt0fNcA6q11AiWxw/ZQkSDHch7tm/T+3DwlQAu5GGOi5m34lQNLYsz575YAJsLKl2OnPFvDuLf2h1XZwCPPxN8uPbmPqWBgi8ywnJXNNxM8owXorIAe+o0aQIx8LP75AOd0wIjE0f6A8Kb2hv5HvXEhxcl2BHsfwDAihiWLjoTl5Cpst9VztbbqH4FJ7bhfz6K5oUw9k5DnaZROaVzwNp18mhtN6nIpARcUrZwDV0K0HlG1552Uvj/85ZrMnEXxFwyaHsZ+/mWTSpnXI5G+Px4YXKpjXUvvxuo1CJp7yVUezko5NkPjEw+cCtExlYyfF+HfPvcqLKlhbJeUUwwBKKvpC6DU0Xwdq210OHPiJEnXAbKutqaUaBgjlf8WGTpo3/YnZ5jVXmDkeZabddGRK7a16xGb8YmgQq0w13KRHEjc2n0NbxCyV/4/sAZKgRHaEl9PhNFqMTSL12WAbHNyeWJcPMSVlq5dOPGO/BkrSWDe+ROW3BaSGSlUTiebONTiN5qVLVEUJGA9CLhoEBTgsb8aIJZx1Tg7p4r3qpG5FpYJ0VAq96isF+2H7zaXq5SI68QPr/m7xYv4KTciLOB48KFkGoJatv1JIEubxiijQcDGZaaGJ1DCmFG3D/6/vAJDhMjxPtx5AmSiyzr2VhulBlY48CBkluNu19phlsU68HCpBVCBCrh0jsJCCc061cBFcqNNrP1JXqp7dQ8LdxLj3suLUxJnKN06171A+t72eO17v7LKIqPp2wvNgoYbk6YOS65FNvHeCBA4xXSaYBDb0hAxvZyTimYKkVNOM69qGcGp09sEXpG+AjFKiQezPF1BEFNJ2qCzG6EW4OInEHKkYUIFLbR8PyjRdxd23owBc9dFpyUOrezywVVGenQPFTpl8Ni5XCi8JL/tRSvvzW5ZG7OpJaPvABqoq3Ha7dqY2NHSmAbc42g9+rHi8KXtRnzBtrYmym3/d+fBVT5aOculPT4BEHwZrPeTGAShY0RRm2us862Dor0/HNkati7fo+GQ/3JzyNZ8Egp/uqB5uBZFGyv7okQ5ShpuLDZM+3qye4fxKU0BxWkUGAWRznA3mwUYROwMuQqehrqv1A2PYvu6JnjsN21l+DtmeG45B2cngVQNSJopn+yyEN+y9vPdOBtczqsMPS5LHnpxa9VwOwdROaXxP/qu8DI9YvX4l3sIc29xbyyjsvVSIeNDOV4LdYL7qimwBJ3XLlXf6DNKu2Cfm0nZumHcLFKQmlNbqmL/pfhKgiDStTN+gESVlOB9Lpg4mzbo7l18WXcFYVTWRsAryH2fyzk+P49E9LUNaZWErtydTxDR77uRdGSKqPxDVQtA6v719otshmKbCHaJFc3qfxQqdnLSaZhgUtNHccnNGYFteSNxIaOefgJYpOD4Fr0QZkqFN126H06JLTMYON/lpvowgOjZjiiTV7SOuH4jcPwX1Hedtc1VlMgVSSEjmsSbSeFAxLxRvWCmV34AN8BTlc/L/N5XuAbTNMnLLecrkvXlhc3OxOEsbzWnyPCEon0ZZtJ7/X3UnYg+ULeBiEV7EB61CwFMCdZHNE9Zc0uwXLfEHywskntwHRrxi2AMnyAERIl9ZY+2JtwiIGgc+MT3U2gUBcyKduoVjySIbQpcpB70ONnVX4xzcYMs3mv3qQ1Wgb8H9Hh8Pf37dGHt4S5bB/RYNanrptd7HoHU38pO5d6IuIxywEo8scng4zJ1+EqVUdR6hgusgxchHlslvMQZrSCm4Hlzg3QyddY5tufzeQ65qsEHw6Pz5IVdElaRfL/SQTvfvIJI9C41S3OQnArMvxx1GgH7NzWGeakaG21SEeQrux0rbcGs1aLHa1C9gZm54ZwjfuV07W3qlzBGa3urbW+YrBBYWWsX3UTFiStNjyruBYula++Usf/4vUG2q6aRinW5u6j6n0wYTeCp78MxO1GpxxLf382Y6ILYNgdwKcUUvquhst5JYcrVBS1v9uO7fDC83simL+o9kPyQut0vObCI/4D1BbmI5iqMyhssGkbgBWdVRE0dClgEeatxiQRTial5kvdY2D2sAnCNOmKI69TF6RXx8gdGzELwxbKDjVmF4ENaXQNa5El/76igyeuT/rCn6uwjgY+XaSLpCAzgCCS8zCcluou0NtrGM7jc4QV24UVzQ5JKswcuZIdv4jafQXkhc7pXIEG4KoL2fLmm9fwJ1sJtq8ygZA0NR70UgdETkzpMJww+GXB+6qAElIwDZ88EkKFQRAZKKeJjdEi/cErj4lbriUk3qMEFMWXyc0iQv0txZ89JgyffITZCOenR4nbm2RZ8cl4LHhrTh8hWwdJbzWBlZd3ufj19lag8zxW+2v0MrGgFiczobJLWvdrT2aRiDudyhztbBwzOrnjGaL5fulASwWV3Ag9ueyL+hIuLzPfvvn7pmq6cpOhdz5p+3MG+pFKW7hbCGOeJNPW3kgodzp70WsNFEGRaLq7hz1oS9FhX4eF2lUaKofCMLtAd94IxVX11YhHB4JGHeLZC8DwINbAWwVKiGJQn6IDRQ5jOEVA9B82O5+s/UC1ffZxiOr6UskxUHYL9ZLjP1wmdlGgsOmMmYo8uyvKpar4DElDlur5LKvRTVdO19sTB5n/UTl7BOG5MT1fIs7B5lE7UXDX7xvTC4l0bCAqN/yusu5zVzfX6OvAJIFjos61sNaRklw9s3AqfHyjXTr19wCim2Qz3/mCrpON2kdY24DF21OpUOTXzDid2xh0hOMuOlW25LDhDmUIyCgyTX567Hcjx820pDt4RI0PGNCPXeJOBJLcZV/OaDfwqEEWpBic1todH8D6mmIzaQo4vTajzqP33cVStBsYIY6h0Kc85QeG2aP6nbdF9miG13OY4YAKYHwEMqtqFvLub+M/5UhIP4Ogk6+5HEtsj4sAYCOfAyZi5cFOEVSfbWrvLuFcoiC3xRz5Qh4KEafDIONkdosJ7BEj/bTuhIEl9GqWXcj0J+Nw5LxMznEY5I0ZFIOJcnlTVq0HU5nGUjr+Fla+WdHSFtM1bZtWvfYu7GUmWCWlAiLUbdy50/qrKoScUG4PRO9VpYWw0eGxHI3EBEg5TRdlm3F5MwqJiERc9LsJSSPJpWXnxcm/JUlOQQ7GmsEApIf8UYx4TuLn/Hw4U5jidrw6YlE0Z4wHTP96rmqrAMbMb0rkoX9mQdqPYAS8HC6jInoxgH32IJMikw9SjVi9zJ20pwWAdOlCsVT2fJTcZxzWxxbO7EasWpgSUypWOA4LwkoPxpmPlZbX72PPNlSWIUjgBa1e1zz/ibj/jVM0HnyA0So8X/yr2N2gf6A1o57zrq5kJbjKREThl9YLaZnoODP8lePJhksY9a0BmdJuSz6h03n800dLtP2QArjMdXTgxxdhW725t5Ioyybk0VLkbJ5UJy/VCQ4/YIM8wcXol0Zldrqaa0GqnQqdJzeVXa0kyOmEPP4dtefzavt2iGJUGVIg0PffU7NYzW+gjAFuFgK/9dJ1WLBdIzf4buYwVOpekjH1BwHDakGF2gjOChgjx0yFUINVh8W0EFI8VDf5qmBByNq/KHpMLm4nE/C2gJ47RMNRgd3ucseEMzvSiK4dso4YPaIDsJbph8OqORg+n4nQHqQhFrUmUbI7cE6jup2UIITlWmeVRqGR2WNUJkUAGxTi8/9lm893dQIcOlXYN8JTFCrwWaWLg4wzuQYqBY2OpzBWHj3sGKkE7gugcdsLkyA/l2Q+aT4f8bJ3iSFt8mviY2Iwfgradly+bRgiJiWEWIyqcEUEN/4aq3Y35t3u79ojtSvu9i2LqK5O02hIB7r1Gnku0C37V6PafxKmiYVK3bk5oSkU1CCxfmh5UiXQZ+CRxhtHaaxKBwKr8p7XNY4Bj1sfzRhgCVqxlbi2wN7ZqO3HDumnAH9nNg+vrALvbjnfv1vabQo+F1hVO9DQQ5aQbzpsM/+1Oqzn/2bhoMAGvtkLf8YMRsI2f42q4TSe1+5OKrv+qWjQIboWo9unwzh3pGh/P5SzOL/sNiyryRaHXND0Ah4kHlYfzUxTrEUikDK8g+yhYDcDPNy7Bf6XH0PM0gpWNxM08dozY4kSD0y26erM16zu4RijXUpS5ek7nfr0di4C2mEvBJCWjHMiZ0OCXvWgWr07J0CuDqDlBWdH2CRk6Z87DhG0WsXJuxEJi/1Pst1P+yNBMsGm/cZkhGxQ1k0qKGF+NG1deKNNv9hbl0+MdfFVvdtq9EUCTDvzrc0xNpjBVLXYUhGLlf5p+rAsUdJyVh4xlIoYkfyoJS7GwSGJ7tq6bR5X20IfFQDRutRLUVeO4G6Zyutq2X+vrexUw2p7nDb/FdePWkNYufTmVFDJ2cIJjc39e8py9OCEvvQ+UZN74NRqyo1UUpOMkNhbA37cYCWUlOcBcITRglqScf+/CGvsR9E8vaCN0Q4kYJ8FeMjlzxQ5opd6ARKSjjmUCwhlL8C6cd8keGc9vE+VvV6FQU8pvTGYiYpUlAbpqTqYjcyk3rJ42tAt5x+fJkVv2V2zrebsZp63wP8EtIOoTcO3dmFna9setPfuyRYkRRXJoEfBwagjMcPMSpypQ2hsQrbTXOWi6c8JFNA+XtgT5MRyZnoaCRtC82XqQxoFwA0BVFpudcRDkdCBuKnhQIs/+ivDZzSXE68mi534rn5iPbLDLpvV1fE08FQsxt2wQAyvmsWHLps1/AUZ0SAgAJbhbpRei1NaMIlkBR5SihNfP1RTjA9fyVo1b6QBckjSJmdomKMtTS5xcwv0NA7KV1I5gGXDxKqY9LY/K0YBBmlPqUhdGTDQlTLZOqI8cO9oBZBbCgoFO2FsntG6+sdizEXntK5rU8NAiBrIpqdqw31Mc4ll+AiPPfa+9JDuOLy0BHYl6g6agaI2PTMpAkXfZY95PYNWrBeuSSyfBCAihcQUZkpL8XocRRtRlk52M52Vv5quSxKTIKDTvqa0TTwsls8uBUYWCSLtIaosgVnZ4jZHEER1P6F5Qpq26l6DRkMaFNnJ4yf/LfF7jSH5EzNJDNkD3BFezLqPt5/aghies9/IK4H5r4SiDlE+bXALtYmpPU1k5tHkHBjtbVyP9BHn+Eogb9dYy1TY512GaxdxJsMJiwMyhMP5kdEreIDgGbpmin2Oth97TMjaczSDkdxiKiYTx12phBPtkcFxBqX/h8PNFuwujCxTR8/NGIdl8gqOl7C/gdTeFXJizKMki/D43dGUldYoJa4wWLXhHl/r2BszxHKAI/3wrVPhrV/11biG5QUFytJNl3GCzX88FeEReTVqFah0ujv9EyKlXQ6a2d6gOvnpyx7zXluR+5R6wUT37mU2p+IRe/lnS3cIU0C8iJJI81pM8UkMaXQzHCTRR3iQH679B9kV0Q1GUQDxbNhKut/mk7Vded7IszVPimNSwseN2m72f7K0Y6FcoCTTPFArBOge531HkzdZgaPfPrYuMQpuWFUNcjrB6BngJHVzDcu3/MAIyUyURqcNKwMBkK/PHJqDvhu5ftwUbCAnKViL28bI5G3JL44vbgDVLWy+Eattipg/Xe9StC4pw+YN3Ml+UQzakzRN4E+7QJszH4Mtlx5Kd64Gu+vgbXeBSb1ybSk6zFdTkJb0f5yt32gcQId0KVINjkQXpO4q2+SvRdtNmW/6MHTu1Yoxzn7O+Ee2n4Wi7wtoSYvOHh4bVjT8SSMJ5VxIYSViLj0kJwi170BODg6YC2QDbWK4rG/exggA/QK3Dx7/AOFtd+MrSs9Iw1sSY9GRmX9DCYzrnugjnGSfwD8je2us3b9shAhDCJ7Of5s6CrM48m0X283Frv9oYSgQz2TlH9U6I3bg6eWPVbq8qwfFR3Uq5n5NSmapsK/juHMHFwHy9hQsd1gTD4c4jEYaxE4uk8gzBMxddIIlgMcAqpGun012w+elMfr4veBrvi4t2vjLHwZm3hMJ5+aH23EPF5cy8+Jom3V20xKSTAu509LugFVlmPbvlrnjznx3hUGf3lDFC7cT1FTcm0Pb/S2RKAYypzhErW3gwOGVYk00InQ6n57/b1DME9Q2oNLUIxiPpZ5/Vcv2fueusjQLkUpbGFWu77YJ4wAQsXIqA5CFJiNmYLDJzqv/Pdkl6lPB8gXTrMxowZlB4AiPuZDMVUMXesTpA39GQSHY97SQwuLx3yr3uUT7fUXNerOxIEiOmEWh4QROpscuTNpeImyI36fYWoguNO2YPHY94mIwshilYrIQKm2vBU142zMvhIFgwTaZkevVN1xbjGayLHiOQtGexujtkWd8J+fS00yF0lGDOTJ3ZL8rJ04v9+kU7vCrgnAP2JYpYAFag/4HOwFrwlFUECMkExbFpZWW1A+ReGh23r4WKsgf87Yh4SGwPSK5+EMsZnNuy70tjxHVpVmPJrfeYWbJNdGN/3hep+/cDE9OdTQPUn8FoIQd0hzdeg3xu0nHgZvrjQks4IxMx5IMuQ0DWxnPat4QtKR+hju19IdbJMwgl5stKTXU4hzfq2NdNyQTBIKZRtLQZqaOrCLSdJmo9V75zEyYRSHmGmz7F7x5D9rbi4cRcSzCHZWqLHT1YiK3fjTP19uykV5/li0Q/eDYZ2TOiM+IXFmk30HRyhKtv4YtKlCPr5aD4thqpDhAMFLPNqh6CGQm2xedxRx+TiVZ8CSXS0L9Ow8Czy9GlPqxZg9r2d4UperFrHPQi14RmQdTqbDbkgtulZnuJ4ECJH6arYysHiZkOYPVHyt6DVYGd3aGHH5120yesMmaPGGY2yS5nozy1dPSZxYaApeM4QI4Cs2XUgSVC80A0TkQ6jPmkrvzAD6xPbsRLIAPRZvR0gdzY2aWQAHXhlwu9VwMRutUKI2bMGJ5lNRnsyk7TiPNFjwveTQf6F/phUe5bv/UrF9aqeaWrVp7gON5aOusCRu123gKiIwH+y63wGBb2dHPLDYk+ukf7Q6T4Jjp3ea3yWXFVHqCg7oenjuM5XCzeL6eqHrJdwfkkqEhBFhwisoG/bbZMHJ17OVJ9QF2FInmF2bl+xbHhTylfu0nzkyKZX+foTcH0GUTpIO2VeARd4TRRiWrlhbn2iHGIDIak6Oh2/O/jDYqVz7oxREPZ+VdorTz0ih4loVi9skqN8rm144cFtihiTVDFmO70hj9Mw7OFVyyyJEhc8UeHcugHfYTlu/Qt2WlIN5TBfPRVmsCaskmuQx7gZzcgAvSix9D+qrIowKmyj3d1acRC4TRwFOpfOOsQmJ3YKGAWhLbC7+cYqQoniwpJXSfHPMuycGyc1yLgLlYVD3PEYO2H2GB1KlmNyEoPTyoyKU5MdReIeKfEp871kl3SEwKL6xdw4J0L0TK6Tus9pUxkYrWXRRE9vdtW3Tdd1o85TNUXN/NsYnf403JOWFxlD8k+CJ39JwMsWIK8dR8tF53G9R8Y0mTpLeQiE3bpqh08YW6tZmNQUpZlWvd6T5j/8PEVEuIr96T38IEVMssy+euehqG+Dbsz7iT/ok5Ipo0VgQ3JJydoNNqUjhI5vs9gXiPh+gphQNsuwq8Vrk+u/KSFzyIZybMu9vXCFX0etJQqNU9AudwRqFmztBnMZ6eLXmbGknDZgS566ds/sgVoE0LqUAJrroE4sbDHCvX19GkzsgCsTFBCbJNEqIU9dsmx+DtIxdxxKeM4QtkkXChF0YgLoqaUa9AhPfYa9+PjSoJtIPMviqMnRMTqF2pM/ZZnXG61yq0ZyrQLj6OD9yukgGVXx5F7Hdf6p9hQ+/MzCC2nUwG4tAyqk188ltvAYPvWvQeyBWzD/m1XNWrpV2iqqd+Ed3Ye+NCGJ+/xGi+ur9EwNz3H/WWvSfXWv9yiAEhiWRKavTX0/0O0cpi8G6nMmdpgLaOaYS8GI14UIzJTC3nk/+Sjo4zhwhByA1qjgK6n99Hji3X2nUe4z9MP7nN7yo9+WhwvpRP6nOSUZECZS+wFwgDla79ol/QOY9asnE+6FJs0EoYz7St5V4AE/50PeLn0s3/jw0KnMB6yeHyzjckbtSgSYCsYvC/oub1bOWvLR1RL9V2rFKYNlnJ17qaljNWIedLAKYynz0XfJY/Sr+s+dpecq59pJPg73S+uwL1KSfro/SRjhx4zpRwoS68MHiwh6sC5lIOm/CllZ/EryYF8OQ5dJ/64fPONJsaEQ0QZcHPrJNyI9eCscVL3BJ4BROzjiAz5H7svnIE302R3CaLz9Y+8VE0NSpuugsZnYXBoTqeNz6mNMcXgA9/T9qtLWuW1wJVYLyKfNvFqZ0UkkKTODLNU772J6Zt1o/u8Jxl6AmqD3dAuHkJ/DDtcnzXnzEEUhIEf7K41DL0T9fRtQTX22FJWcnfMFKVZ6E01vdN22qDW9p99dxhIXnOqQ27sSbqpTbB4sAw89Y4Xsatyqx5mDwl66aHDMdXdVTeW69bcGe+hm5DwoT3Hm/Lxp5MA2NYZHXH1Z0wSsAsgvRGwDIvIsjeitgiYcAIwVrEXmfTON9dLQ0nBtq/3zN+PnJjLwXx0ODyviBNptBveBnHpG5S5+OXXasvUHbvwyKv+jWA6dx6QvdPxiw+ZZdpzBzDCvkzJeCAjFPcDNtNQKtjg4pApcr+fNLnVitPecb7kZJidxPr+opSn0MN/gY/7S8T1bNiJc6EyMhN2fCNZ/aoHPlJOZNPy4jaz0A0BvY5IXSGchoD99YtzJe9en+44iENeQfeE/ghRwm8EBTH0gf50DmUOtJ+dpXHbfQOTtMZoqEtiD7g5g7vySrMioyt0Et3l6ancB9WA26baw0ma8dkA+YHLA4aOgg2AkTOABMqQNh4SmkizPRivVRTpkFPcvlc/qLt7oeX1eVrRFEVI8CuIzmLPp0c/STu/aGGiOmNRt9xukn2gowVSi88DVmuTk//td3jE5QTyT0sLXuqMMsIRMWWmzPUM92CTyoy/9UZfoFqZwBa7a2DznKiIox7azwkRM3JgdvRjBX0d3mU6N5h5nE9ZSyUO5pEYfOtqtwCo1l6u9TCQQ6HfJiwjyPzAONFelQ/J/AZ16QlrEFaW/Ru8fbYppkmahjl48adKiDwl5igfn3o6QfxIrDJOqFB41oXDBkMYSWgiL1IvwX1E4ktl2KY2EqmC4OO2SmMbw75m1VmdUu/bIJwM0hRDpW2nDQJA675he/splf+JOcZtIL/+t7YyUhX8p1Vcrq1gH7t2wp4WLu2wGZVjXO3Ypd5V2hvkyalDUiUL0+6BuQBrw7o63WVkj2TsArnSVcVHofw7fNYJnHB4J1yZxxgise6ylVDiwK8xq9040KwekbZoqRifHRq3qYvPieEvui/h2H7ZsCiUREAxqBwKJWJUOl5n6ueFB/N9EAp2t7vsJ1fMfZf4KuMo7kxNg4o3Z1HvWIO94UG0e2GhNjqkMeN7atMgSoucgz2O9ivqi4hWzZpVvIaVu3GTwt9xnEtD6wM5OB/U0GcSWDu4xslRo3r0mLYzVJSWsd9PMOAbE5smDfRB2QsAH3EtBeAP5jo5HwOzW3QMhJW4VeCV3/W9n+UfHJeFswkpzf5ACMgzBRvCsTHisp0ml7Ww8/6aAtRgUZqaD9RGoXYISApgBLky3d//ng5VwmNrco2vjQVhfEk/FHGSK38z9kO8ahQD/GJoBJKQpfRW0jHJ0SLDDIOq/sBu1btRBt/ogHiQtJhMYZQVukR74YXdf4uHoPxW7TRxwq6GUNFYWNaeeMc2FRy+FbbjLlRh9CYWob2sSzgftcUx0hA17et6nYi9Jn91ftWLw7zq/VZNC0rUMAV2Mrt5OhDFI4Z+0fwIlePsugOzHuoK6Atlov1qMdl8nyiKQX9BqPJ5VkaHTUAjJXOC7BKD+NZ9EsUp5niyhXVGu4s56UEfTwEWPHuhyK76TrUxAXCGIl+6FCLR8UqnrUJ0Kr2MBWwF1iLBR8PFqv8tPFRkiG/GHqGjzkAd7V8ybKEA9Qiay2IE4pGz+Ucj7hYkWKtm3HgzKlxgEUp4JgQY2qc36QwVQuIkQ/DtBgCk9koMgmiO19MEwmBA3OlRg5U1DA+mH+7/yZjKkEjPEpH7SpnWwG7AcF06rt4nfp6b4GsH5ry29xedZgSeV4yONeEhYZTUk7EzGGhkzo4hq6xwrGAvX4qFkqzR1bAbvupwNY0IIkuHjW7IgGeDMTauqeeaivu2Y1OO9kNFr1zXFCJMO/y8FSGOl2F0cE+HdOVtWHHaVT6GRkTTiWzuziAfzloiAl2C6uE2fl6ERxYCqd8SnlGpdpVydOnnjHzgIK+mppRfYcPhqvD1yJdA6/NL1bN42do+PMuZMY7FQ9plladIr51kY9WnANzfaQZI6M5e3iZGiWKE6iv0vdrycT0lODndWbHgzaHyFe2R7soAD6W+ANvhsG/8AqYSfywxPj/KbMrGLAae9rgW8ERE9dyVUpLnmG8jLhmcDQ8QLGznFknOqy5hutrOGnVCC7XgOf6DO5hhoOrgyry1uCN4rj0SVpFMsFgsdP1XkK90dTJLkELMfukXu/bcwv1jTyZ3zuX+ECP8esuHG6k+WrYx5nWVuxlO5AHT7rthJWKgFTCLg+IRBMiG/X6nRi7Dp0qoEXuYwokLY6Ym/KOY8mzK2hMGKvCMH5yN8Y6Y1yryKE3uMmd+0R09hloVdoK//PK7NoDpMf6E7H+JjU1rImWfrD/1jTXjHmUDDwGpUejscNhwenwFcDCkilKUoOPJd3fOkEhApPYI8wy1jxVateqo/fufpDVTMcWQQyeSJWJrw/y3ShH6UlHS+2QiDMsrhZW7kibMcd/ndOSp9wPyOPk3XBi5zFLqcCBisEJHclXDgGuzBvCKssiIISVOvlQf9LTmamD2F0EpNvggbftSuWCJtElyENyGzzw1Chl7+L3t2zhagY7FNm2+cEqYiYN84b1wh15qOQr+WzJQW+vxPvNXFH2ThUSXRwX1Qt9izSETLrMh52z5pMypaWONDgtuoGwpqfD9QTCJ7ADyQm7AG4vHBIaYVBiO+xgF7/IMFARnOuM2NWQ6PgH9Zv7QQstYZSZaJOwOxZCT8eOGS3+VWCLt17OTsNYdNfgtSOwjEDCcx0v8p5uQ5OJ9W24EVcX6w7oMS4NBzZkNkQvSclUp3urUmoehcmNTgq7JtUIYcDsaqFcez+/NbhDxSRiRWNS7d9bKJ2Qm9ZbeBehpMfXbpmspR/zm0sdKPNsR1Xuy+PhO1Sq//qlj+pH4pReVjlHXQzsykU8osOhENEwx1uK9ADiuqUzjzDDEYHq0W2yY7kC/RvUDiuhOQQHi3VZKOZHcKGyFhJIH/ivarp3LLgrBZKh30mXBu1DkX1yhUiVbOkmnMGx41RTpTSlEETYcLhyepC63BmMa8YLJkLjB9zoBO+Fh6YyzOAWjEGnON/y/pUC7FILSUcIqJc+ohzVbcuMpkfTCz5rlwMc5GwbdfD9C+d+Cp6Co80YAVRvVMSVTdu85R/VmxEzDb+GkXNwpu4fheDbT+ORXdM0QUwUhHYtThNGvcDXij0czSyIIFhHBXyi9Qun5/Rc5GZk5RSD6uXyfpw+b4PSCX4LxY37pFkzLVL8Bhy/AnPnrwk8Pd5nVD3tuPiNb27Fe/xMKL4v4wPMbm2Kv5Ayv7kdG6wgCqd4M59TLIq7OxxYq1cF20mWfCMTutixwH8q2GQi92GjwSrsCLm9NiyniQo8mAV/Vv1o7loDUxIXdBRWzN+9tDVIczHzS7H0Riul1gN19r5f46Ly2QaH7Q7ywyFGuqDTmvdQUZrRZwoPvkcv0uM5q1FAZB9cIU1u/TT8rIYSCOyh9DoKl2ETcp2tJzRSdlWXntBmAgPBWUkTEeo8N/3RcZ4xYXpUQ5YHBOHxm0dEvw9wVkC6s0rcaFuKYbina1W2NDflGC0ds+9Cyj385F/r93//G1Xu4ii/PsmWAZ/q0LejG6j7ll6LzugjqpE+i8zmoeGGTy7ebSYES7eLAGPwOTqfPBbRngUJ3YFeFJwZhjy1ezHQDr2urCEE3+beTd4UeLOe8mN7U/jOEzoIrZaDDutpZCzh8YFSFKOY1b98KptLqcPtWSK9P/o0n+jc+KI/5kZA5nF1ZqBkBPQZs6KBJkF7AfTTxr6mwJfb6gNh+GtbihcQNRz/YL6TSMFJRRfT+cp8rcAlCF7OU+9oSOm53JYJrQOL7OMloEKloYsOq4dvaGlCov7cU6XPtBtSBOislBZS6U+yH+h+ojfPX1bUVyR9tAYZZlmoM3dAcghlAr3kDaGA72XgF280DK9SMmZHHstLIfYktXB6L+g31DtPbFb2aS1ErdjnUV2ZwupLn73dM+BiYVDGdQ6Dl9bK3impPs5mnX8NdAXJb6jD0Mq1TRZo4RhkTYddNJ7q6YN8PO8gSkDB6fTSZk9mwLXavV0KdAI5JSBcHHlCtPsiwPWsUQ2d36Fdgx7BFngJupBxyJjuA2Vhzkwy7mUJcbQ7S1fDJqobghcqr1Pipht/imd4iG8maeHVyps8I9SuFOQ5oQlVmvQDpd/dHPBMxScY+eKfj8R3zzOWXd5WshxS6CCQzMnJhQgGdk5YY2/D3u7IXRX3JkyIwZemvgQucTCo/UJy7AjbjQzy9uBli+dYz7fizsPh+07ex07auYKV6GtY2YbYOwSmSHChomeJKdc3REurx5ZvMtuvzjpjXoT72smwJnHcIiEe9pVUiv5uV/zMEIE5nWz13N3Tet3YCEHEnTM7eKh3dfnrXA/VHsh8bzzHvhmLznIG1R1swyd+1XxhyOB+XHRkCrg8nXo4vB3IZiEgiQ28b7eC+xzEjaOAWhWrjqV/4ZWeYaZHJaTYFiT3BqYyHil5Ow7MoqQ4MCJp6tOjItViAyYwLj6u3nmqq008vWxCfRajdT76cgRtNbiB7o4a1HNpDEpYhp6Xe5QI+OyJlVgAmOZwMGqcGWmUGFYCqBpczEwkhhRTHtvdzry2JdvPIo3Gfa6jR5f/UysSGmIwEw1Gq78ENREgpJfHmYQhveKwKv1oMEUrVtOUakzn5W0I0W9UwZcdyuKJQIG8eNOFcwRnm2rcbriOIzkfosUJd3Bl+1pSSm3JX/egosLoPJ5OhlX/x4DPZs1iHCwhe3slaZuVS9ogCnRV/Wu6X0jGhwYW8JfIgpH4jUwbwoxE6MC0vl84M8nL6ITerNLxpqLzUr+ZA/6d3b2rntO6OkJhJ4rvN096u6zbIPTonkmH2N4ROTAj+nV+vuzjOhgpi96VXKA8y0CoBvaVmDr2YE7F1rirjuT+qw2IDAJYopPaKp11AMycJzt6VNpRzYETuVq4fvuazT5PJGWcW0nLfCUNOWaUs1L4RJj+CnHMAsrbyuey9fDCGtteTURxo4DagiEHOxfefgAVMohTwMA1IvKfVTDTy/Kwlh13c5HKHUnnUsZ7LNlZHi9sq/ap3+6sIBGA7/Y7HPyF2hqjVqHQvURvS2rdvyoT7FzUGV1KWkUWCLuF2nM6YBujyWMImuXxmYG2wrlQCcThuojYW9M4vk0hrKSq7sE8fVVLZnCTLE68W7BOZtZXx0D1rKnGWnmG1mqPVmzC6lYbYGeuGxqncTxZIqLDfzbMIqdBPEi39TzDhg1Z3+aY0QuvFSiXnQyWIQswvHf6CIIxS4Vj5IMVaAyF1rwEOxjbdEeKjSb4f+76viGyA9NYx/t/D4iZXKdBUv2F0scGAmJPcqtjziECDwKASuh6xrkYqPfJ1JZccP1Z30ivnDTWtfKwlE3XIwnO+Vwjwh4ZC8pAY9pZUYdSQa4UqO3jShBpkwQSeGp/AQtB/xgXHu1uXPk1tP453is4AZca2iTS0Al/zEuxtekhroz0UpMGNAWDRYrdnqzet4ihnbQzG06hlZSeMHAJ4u+HDEQ95p9m+H8I7D1qXaRDAaoZLnSEflSe0Ox9qPK4OE8Ax8acYNZi9MzUa0uVCmzANzthI7Rq/ALEgiokQ9/REvHEyqNnk1dTsYIfNi5USfUidRYmiQ53k8193zYCiGpLhNgqTN0bmXUqnnLj7krXjO5yYKEFYyDsIbYE07GwjUpd6h6lYHrYclI5kDiD8VsFyZSi4rgD7iN7l2b6vmnFtNFPZAI5EhzP8O01JzEgFHXmAt7mH13A8riXOGjU8I9MLTHArfqOnwDfioe0d+2ET9YGrKrOaCkW5IcMwdAiIdsPNU+0oeK4sC6abG164R4FW1zbswjklGm6IOmKHYbjzXLcC2OH7idec/yzHk1lvbqWgM4BKgISmDMtA3alwLLaa83Kiiex+gHr34kYK4j733LYAaOPWb63btFGAP5jYOm68sbeGRrLDC846l6mKXsYVEmdagzGhG5VoDfsqJXDnVQhDGsftYQ8RY7q5jYXOSFDJXn3dwf9ZWKrcFqRKZ2/08K0SSsU2oLqxO7PueDcLCgAXYv5bcUtIiwG+IebmyJjcjcpjvahNtmvW3coEWz1gNpAFPjWQIiZjLF29T0/EOpXaqMf88mhKbQTK+TFWyk62KA2GFUDV9n6MISQTPvKh34sdLZ52J0Q3pvLx7/BfC3N+nASeGQlZX8yP4yMO29tKRHSbJb24T3nYGkBMnVfMJWxzftAAhSL+/PRKLJJnhGHPM1HyuWHdfxB/WIITsTNNn/t0PafNZoopC73nT/uyRyj0Y5FqTyWiCzWRUBeBAeoDudzy7bCnuDJSDDFa9hcO25S1H1uSalijWeRKvoeeJPG1QLhWlLUs4Wwn7rekASqyKeR41X+uPty23e+XPYQWhiurBmu1XDGVNdQu8WbFiXb9puxRHbGML8G5gJwddKSwQC/L1zmpnqkEHado8ZzWhrRjmhRWUoaKZ+dyGgkK2pySlS0HTTmTIC7gPdVx2M7Y+JjdzLEvvkgCbU2QP4XK9HzQnds/siuj6s4w/YOow3Y3sWWh1VJ5Qd6tzHEgB49eRIkX8rcFbXH+IM4BR9Bg4tC2q3HfcVVBPusgzKorqONozZDyenorTXQEMXXwvXZtcBhB+Bm92C+y8ia1R8ESE11dsah2XPVwOv9yZWYNehcQ3A+Jlz3Z0yN5+pRSVth21b9QSdBcgPnhe3SG28qMU470U+g7BTt77K6E3GoubJRL0yi79xQkEzoDo2sqc8QTlGjBlqCxG5YeBxNrgHjU7Sxh3VHfS6Mhyj4G8ymZ+WxJ5kGnAGLynb5a2ZkXwaV5/K9lOpyRBwir+H+zuI8Xd6W5Phmclt02+629eVPXB5NFMo0Pyp40ATSQ0pTQR8Ia+eL6waFusJ9Fkj/9PR6Fm855xgUiMXxPc7fsUbORAToDQeXbEcqWFna1idTespktTSbKXRXqN3wyfLYCqpYXu2BbvZhD/Ma89hHj1YyI1BOWeIOeJfR2uaMfxL2aA3b/Pd9r9Uwxf6pj7BknDB7hRwtIVZk6ZTxydqAfWQzcw0cDI7AUJB6UmXXUQFvqeojGwJLZFG/5stC5vbMu4v2ZqjuNqDdpc/HLAVJxZ9N6utqDPXYnLvh5cS18WAMMilRerHPcjMiP0OQRgJyWXob8yCWiHhcTvLCCIJ6EuqjczZwY6tQjT7lgl6SfJvSiistB0gi1Z5hoX5Rw1NniqUQPrTjEEG2S8ZdVMOZQX6XHwr6jGsarF2ME/6rCtmlSC9qa9V81J8uofESNa3q8wUt/yKliOAAfs00YgLfpSPxhIJdaJk88y5NV9yCAajnuNtD2Pk5R0SUM808LzoUrZLJC2Kiax9ucapkmK+vxm087+nOfDwMOjOh8nsfEj19X/dYcwiWZEEUz1kq0AFKF3yDYdv8ypSvzvdiWHU07e4ABUAhJgVIHYfaj/HhFj9sfpUkVif0tTDxMrMvlPV/yXkhPS0m/2q857b135qGMHoc/Z1xEy8WvW5Ro/n+IjulVMvAycIkEOEw4zTmCkmRud3RcLdjuQjvQ1XoEojux0J0YjQ0JSpAgA0maUN5OzWtKcUXYbABiAiGlQxVSjvMPQVNIkaekQY+iXPk7u/Sd6LK7fUSEMtsK4gCDzUo8jgklw7ozfbSJcODmkdyovhCvQAzdFW6gWd1iIL0Fj55Rue+NVpWhwvSTI3GGDAGCNFNqihAcuoZoUh29PUvQ116yqLXal2OXWlkGgXld+o9iAzSoSUQJzNyR0pAkIpTx7qK7B+zmLW3pZhsBgQxfqjC0J2kpkSYhwPWesMFcaRQUgLsddhYrE3uPltwT1kNpjtB+7cxPTltiQhdBcM7iJY+kndpZwi1qr7NcwJ9+qQyaomLEO8m0mwW6LYNfBB8+stNThavWel7GOCYncmfNWTT7ouarNPtSPAMNRlq3BtzGRRd6pqBwe9E54k7EVKB2AoHhGsNQSJj156jo5UfQTNLvaRybQAmpvl9AYMyIikH4OAaOMZHF8PPZRyE+dVEWn2C9paSPOvb7vKCTjjc5cT1kJgZYPqf2PR6EEEodA07fgjjZUEHP6mYunbEEGu1e5DP3suAhaqO5oJxEWUDnylQolujgT6mN1Dx0Lpr6GJKeqfFdSDnDABCdmwIEkEnv3/tlRmML15CPvkvgYqEwcC9Gtokic+ynLN0t6vMmmsoOH0IwENvITFZZfbLy2QMrcr4/RrYktOgispMu0tSKClDF7/AdS6kMu5A+oI0zaYakZgKqARFQG4ne9d08pzkdQQN3CCHP0LMToDKyj1h1Qk+3cg/+OB1obCf0bxlEEiRd/biZmZbSoUTFNQYbX3Wo8gOR8t/q3LmBVUOia1C0b8izOun0bPjYWnilJcYQL6J30GD784u/VcZiE+3h85m2dCHWH4uBOj1AaEtT8fmKsqmy+6vSkUC5MInG+v+IAPfL25ovcGu46dSgPR2JLd0Iub3eOX/CXtQMUbup0NujrHSgJTdgYLTsYeI2YhqiVT5sE65GkYeiac9QuncLIs2JyYi5mkYdeVKTGNGgFfz4D9M3gezMXt/pDfAw21Vx8Fv55YQt6k171Y9QwhROrrA1tnCiIPreTOyMQtfDKuZzwh+YrYjtWS9YFYtH2qef6DRgnN7PgeP9zaMLvucQqX9p6Hxptd/8r34BxfdB6tta1r3DEoESoYau/1AkVm8BrQHlpbqtabM5uOjuzRXN+uvXnNRAC8EF90jh+U1ykk8Itas2lm5gAm9PKpVQ+BqNGFykzNK65y2LC5ljQ3+7xpF88ih7XwSSUBzalZjmbORn+0C18wubsuQwhtOXtvW4H9vRdRHzMMUgKtTQ377h+8ai/L+hic3SV4IE9Fx29e8Bt+e0sSSQxzL7yYBk6Efobb17L00XKcBr08qONnSNZ0PDWc3MAMwjyuyYHf6K8KmKk+F2PSFy117OwKSYjuUUaHPfn4eGh/qEBBB9X05LBvK0Q9gxG0KTHFFEWcD+Qwfjh1wDR0Q5mwLQOZjN3Ez3eFmlAtvOyiUoA4wbGS0fNqoPK2Ve/XS/UDxq0Cl95H2jXSw+qt6XrdGuchy0Suhi2SlXSHox8XFp91C/FWhEEgvVgT8Rpnbq6J1MCEmn4K0ZVk+55slYfVbEutSPj2/GJHgle4zuifrsun4Wo3uhYnqeNICw8LOyAQIY5CTDlcUVd160IqauhvqlUfZ7afYotcoN58S/ht9qcs8w2dO2HIC1TFg/cq4LQ1wyxX9vXOfvoqdPzOJJVPd8UvxyZ3J8IhJeW1n+4WX1f+oZUi7jquhQsp1zECB/WUjtwRMxON3U1LoxotLLgwMNyKX/WIkJpJJlYsZ8bhQ0Jv0VPgM3mOsRhx8c0ChuO9O5ALUOGafI5SdvDqSWYFGNZ23BCxAFfZsMaf1iuywnT4v1h1W4OvSHAZNGA4DO4//A3oFGPjbMERaxgm+fx6EqrL7I82+pxPukcpX+IdVXkTX+bP5aWFRgphMB71VYgLh1Ri44NzbATKPJel100JGmILOY+SQ02gJN72lK9JqUfovzaOXXdMJ1m1xBiUBEZhINgVJ3C8sGU7mUpRaY2+Hxbsu/6DyJO1nMnULLScYoA4/b08D+oBWVeY8zOtGHJ80sDBIbKLs8Klx3JaxR9cVjMRmo0mnPessmOzqQVYQNRSUllZXWboZkRCT2ZGql5QnP3UIll+3JcDN2WoHLcOGfG0FM/JJcFU+vAVYkkSLmp3Nv2qgPok4Ni/hLTjFd2G5fL3lnjFCHLVpqq7LIZ29N4uG2qle3qkccWNOBNwbJFogafFEWKoVRFGOgAJFlK1+2La3c7PuLvk3/KqAud51lmQ5pSBICQj/jN8aygPyAdGoENngPAXQ3nDF0hN3uqII5pWRCdPh346iAaaLpNkzEyqYVy+tlWvCCNByXiFlou62fSLQVY2qCyfrZVnnmS98NfsK0oTkpYW9wyXXtrS8LcmlV+ZvlENjbD13J32p+AtVYWANXCrZ+SsljWkU7YokxH0tarHiq4x7yFev7nhkXNNr5kpsXAbDfvE3o/QzYV9nWSmGS9b/OS02WyhobOiofdEVd8P2Z04NoBJvC5fp9AyE6gzn3LJPu9oQFClGs8UmBHdlyabG/5ODTD2tWaWByQrau078X0wMWtQ4uWD1JE0Kjw5IkJIOgzvMOJO5lt5Mqtl56gyFZsh9qLV8aiuXc8XcYM9QO0qvr5QNF6uWGvBjWK6QulBM0wtypXYsyQjPyppmnf+SveyNzijFmM5hRt9WhjLwnhrF280wdOiW3aa3o94umMkNQaiV27go3FlNqVnOtrd7yMHHP+xgqntxwZQ9YIJAFUW84JIeKDZZ4K3GZB18OenP35oiz4pmJr3LyX+48hhfA9p9W1MAji9LhyyNqtSZvrncEDgLF/tqBcGR5AVKaHlGscFZVh/kvgsuZaoyDrNPG3TE3yVMlji22w85/Q6QuhlZHwHo9Et1mPWngEv2sHauEP43jYuzoNuWcCIF5nW6f6JlrAAs7soI8a+S7ZXoJey+4NroHi0/0kRNIE45XMhjR6GKGgXK7DCBxnUp8CfkuoeInxCNdsk5isB6NDEm/xBXDKGfBBenw8RGCrHjGo/wXZyMletauERwmNnSeSoymZ5dP0ymVMAnMVPOQ6/3Ot0/u9y8S9XEX3yFcNY1k1fb2AeLNS2SQWwVFyJqfqJc900szQNIXbkRFDUzB3KoWQXDqUQ1+oecOQBOu259ztXTHAxJIKpsxyBj/LiJ8LxpIgEnpDEf2S3XGa9H+9WeCj3qqpCjlVqK4fpxGzbY9WkMSr+CLUYgtVt2rH50EeyE5JPZuaZwANbcBSgLIumj2fKDgMHCgkwJuTqb7zC8RuPTeChkputQP+qslKqDR/KD/oXxSIwpOzyNcBGfTunUvsk7bfnXk+YJY+6WlIBCapVpvI3VtYqI/77+HyE0W/kNlsopRed4utjwbe5i8BDcd4qbKTuByNxaw3n8Bv+iqnjRaev+g7OUuoghut8Z8aQIUgGYQC+xs6J6Ocaln3J+lYLfU1si9lTWfeVBsMHI7b97katnvo5Huz2xLLRvpHgwJdJfYTDGW+edaegC2RoDEp33Uo/11kbPf2ImkiRH/6iDma39/j7G7tZwvtQjoG9n2iNKf8TMOXZ6R0E2bahPwUWdEGLpDamWXw9B/fkxXhETEMG4907h4vXl4WTRVIIAKK8cfEc9t6PVvT8owZay0moUpMIadKO8wReLUDCFRd+bQfKe/kgtt6S6LUYXWUmzSy1bmzYLdfgRPF3aoK6Ud2Ndhb3Che5O+vRYnvr7hsXUryXgNMPA0B9s0J0PImQWyhhDOSxZl6q9hUWjMIFzjoE3u6RN/SGyMSjuEQebycsCmg5E+OKfZFkJqGzX8w6SHOxW3aHpFRPRd6DYUrztTocFXVbwDxrAr7FCv/nJgrhilhVJyhi25wo4yyznNaQp/xcCTjnKAaTO1Lk14aELoMg0QpyMfY9doI1VibCsgaQ1GFsHsjx0jLE8i1F5UEC9JF8VAuUf1ho9qWdJ7RDPeXbKRNJkIG4O9qQ5NfPOApaKtCE4gMJBjp3/LeS4c1CON2h1+cW0JbspLlC56uGjGOAJXw/f7av3f2NoBfQTGgnJyUBr5pzJq8sUmdAoPrQtIGjf0TReADEw/OPlLxH/+pk2fgqjefjiKy/fJdVUG3VBfSwq3CWoX6ZCFuwLrSTsOk5iIqcofXxJRB34coKDUb9MTUZdgdWrV1fOLgtaLH24zDZHgdklWr04LDezh5VWVhFqm2N+8z29IrapzijG0X0S1PwFq8UFTDoIPABITfQ9b6WQZBiS/kAHCQjfQ4tGPdN29FKnVfSam+Z6H8CyylPkRqDS7pq7ZpsHi+u0SPfUYr9HQ31Qd6nS4KxAlGB5nKweXFY5y/4EzlR9cztMav9Z7bI6U1PyKmsRnPBuDfPN4dbpl86sQqLAkWrZgMZjX3xCtwkngGqemKlkfhh9+JmPE0h1PzBfk6MDnhMvpJ8COBJ89yFBUKPGF+H2QGyQ+K52SNQyOeCTKTULyExL9CS4Vck5/mgozcnhc7uzqjHHx5Rs5u8XsfV2prZpO6vW5/XVKLPjSjc7Wf1XooCRZ1mexd+bNokWHCV+dXFmo2I82JnKb2wEhqkm62bRN5K9rzYkzLuaJ9sF04uqJHUS9bl8Ifzji3itp59t1+sRutpH6c8yWuHAh3Fbla5RvOSao4rUJWwcOwd5KPkFDInzr9MiJSxmjbQh6tL+RAR/qhK921uXPTy0qGk6Q5+EbX+5gENeapc85ADooqEhIwxieOuZ8MjG1O0TMfB5X1oTNL/q+G4lEVNIPERue4EdGasQSGvEtdBm1BUBBtCR7PGi2oJyRDBq1Qzy8roaGBmW4aSPbwAcvpoMLXCUjqcrEqI32AXUr+iZfy6ArMQ34Jf4KwAwLYcEQf05hMFCzF+SL1nGw7J8ujcgMJwXkbhxpOwXk7eAntSR/Nx/Zl+U3wSstTeOPL1wu6llcSdZjHo27xuOuH3K6nRwNinXDcY4BZ1ebTbdKH+BUH+YhLgHTKpvlYognvUOAKCR1LE7bnkylbyb//gFc6EIiLXr2lQFQdI2jm39v1Mw1qJ5iupufh6tU/993tsEHsrQIy/Ti15TNMNqoBfbH7QSI0kYya2qXUv5bNIaLewi3COkOPifqnelJzqwYxMC0R/7oporo9eI+b9IGrfHqj89mcOepfqLu8GIueWwAnm8K/vNSUialO5DO9CXMkqeIhKoEdYqMSTtbbBJFpmrg1rEliwgQu4UOikFoJ5zxfwCIYGeP9lZB5zjQDIvagbOa5XzphgPDeGlwknAH7UBGZhFeAJiqMgxYZI8tsyzwlk2CNKaSS5T8g5QINQIl52MqxnHBZmpeE9Mh3iP4QwWiOuhCuKosqjxCtU3eIorvP/2XUbIJChJ4RFDxjAWQ9tASMu4CqieTYUIx9Jp+UMDKquC1dthBut3ZNjHTyELq6Kw+7MPJCbSr+LLm8mBKzJQhn3GyAJpUCpxqFZcbeTx2ijeUZoGbhrF3PoQpxTDnXxIQSJrGozbWCteBLS02nmDjePPe1jpsQYfgJO48cFpok2DvLW8CA8glCHuKIl5eKGtRG9mTkaaCgWMgVkGIya57Jtskq3xnBsWivlxytgjLrixPBByCEww6ctNgdCN9HrwXjxNR/TFJ5l12IbJBES3h58Rmtwmowlhwr/+WQ4a7i3a1xgW47fLZzrPfpo+k/NCClDXCVgq7SNyMgt60/3NL7KNM4bFSVbxNcr0KzvxmHKoBmQhlZS8GJEtCtM/RJs6odDBYNcjE5ACJ368YGWR6dmIiGF9fs75FVTbtyz1Y/wj5D2YVtDiMusiKbv/2WZtI28Y0LTYncU+WBSTXOT+6kgVXG2MtgZxyMmkEgzbydYyfVK8LhDKRbE72GhNadheNtaF/ZG5jWh8/VoN/3BpF/lTQmjW12rSF3QAyai3iGqoxWcIlVuhVg0+kJHnz12ziLMzj5/29UtbjdJy8N0gRlwug06qGjoYkFG8Bb6dmLRki949Iz9yUD24YRk8Icl/qIwLNgtcUlzU8ff8UYN5OYsRCs7ctCaKHvCJrJkqp9mdYYVH/mlKzjKYVC5DB4KQ6iZRUAzLSV3l18fVGgi2mJGUO36re+PYF149tTqPZ5LEo+3EhdyEn7mUZkM8SrMLV48MPWCj/LS8KTQ5R7u3rERCttsZNBeKQwBB0/silsC+jwmzkO00Ud3mgnah661FpNtGZoIG/1cCGnixmSCmoAzyzICFDFmjhQk8jMmLEYsnqcbuSUd7g8V5MTRNPkEio93DyXOferM/MddlEox4CADgnCN96NYwFowGuJdrxqHJz8o2a/hEPPN1gomJzlSvwDpHpjp82Kq5lgayb4buOIObe2lqkkuV5Lyga0ti3hxIvCHaJO91n0MQG/RuKxmknEUUfxf5smMvRDsq45cI54Nv3OtbeffUzWWh5Q9itDmmfIG2eBx7kKuczy9Db+h/1DblQw2iYmKbg4VTCF/pDFAM4peOufUjtZqWtg5Z28H4k+g7OQXDXVKuKAnAldY83PtnRQsOesFPWL26YFF3Nvjbl3zG2PgVIzCUjeRLkjU5YmYYMW/GozBtpZpwnkv4nAq61OhLAFlYDfXbJR2VDRNHPhq9AVQ+xawlLHq+cE0L8rJOvfBPuUScJZ5PxHVfKPfIYETSAXMFHr6piFxOmEB/4BZeFtmOgxd9+5lbZmR7XCAXecpV72YPSyFacRAj6XcvGjOrquMKBTpwoUjBstaiI0mlknpxNL0awRaDtogNWW1yPzgA1Ck2YBD6qJCLDS5tnElJaSvheK94j1ktZKrg+Xl2bK5RUuZ1NIE7mQ4cgb7V/RHMggjWbi57UvstZUWEgeUbwaswqotMs8fddI/NH5UvSgfTfjnsyF6yC407DVALVLQqQf3YKgt0pCmWRsW3uBlJa2BP4LgDVtCuPehRKt6OJTnB/tscBi5uVw0DgVKRGxu/SYletYT5QGuT/VNBVX81z0ZcpWEj3FpxnIGzP+8lbue7vK6S4TXedCtDc4W+QdCDcG0Y3x21MaTckZwGePyHjVRyag8kocWAoj0hrspn+oTYQobRKqhZwY7KcfsSrjg7WdwkQFyK2HFQWVFig0iJtZYw2B6OLIRq+lgEB16m/0v4av55MIdsiAeB8w5scH+er3Y+OFA7AhisHCJNux05e1saeiHjiBbni+/XttB3s1Heemdu1j51i688hkvWAP/L0LmmetN5OAhVwdgH4YwQhvPcPtw+vbtu425cEIu3rIG8+gwYkFhj4550ycViwmpk+pVBUA43FqcOJEDVY74SP72GtpgV2PHC5xQfeCMsiFECwWJsf8D+DOy0m1oQFyMXDovpmQ8GipgA36S4WYcR5w6Pjdf/6+djMKT8WeqovnyLjsZ9MSXT8xqwf338NMtmUz/RA0LQShrS7/9RB47EYgoGwr3oUBzFTbye2d4vKV4IHkpkJCBg4U6rx8AUtWj7ujxU9XQAIUHIUHX2Z5J6o87QvGqhsQ9VREOvNj3RbSTZ5Ywek+Wv5pg3MFT1qaUEAZdj6h6f+zEfsNsZaWUSYI64Md7QKSc40F9mtT3wzo8RDss/tdLYstHVGDTvqsL5xUGX8nLt0pv9dQMfliaFEIBtwEIz7YLg6tik1mNpNfCZcsfgiB8jvtvkyhsJuB1kcNy9Ivm/CO/w2Xebuzsak17Psvjkyp6fbtB6z8x49foeydaVTpnmKE9OT2izj/eccSLtCdEvGXvgG39ppsi1NpJxQHYSd04qPFQNBhKrmDH/ZHlOao+kdfoOunn7SxVziqzrdmxB1KOcU3g8/VgczatXzusEu7Jd9h7l8OKIJEMh361/4SNPWBVb/RxzBX33KszYiYdUACAyFGqg9H6f+lDO0j0nYQvTAPwHJx6sQ1O0cD0JvE4cfvWLBqG4wU2c1CSJ/TzGEELL5ffTglcT+bcb4IDTNYXWOMd4PyDQmcKKxkFMnHBaFKVWmhTGTDQqTeXKZD8dG2shZXsK31PYwGITCVqj66Jv+/YPVQJS+4nuI1VYhriAEdQWaPwHlmRgPKn5KFhxhsLuGYFM/UYgZMutf7s8JizzAUgZHteKX7Acc/IhezSi1iEoHJGJ7r+qGLnWK5v8aehNnEEyCtau4Dfv8sJAxs+0CSdxbY/u+A+0phItdy3uO08QEKi9xEiuXd3wIaXzE0BTr877YOt4p5Cg65sqPZ54sSHOTpbXtm947cRDa8a1oJDWwv8OvpsKGTVsJhVr8y8DgjZlesEtRrp6RCunocV63TqVrOCgdooIvKL9/ZiJbOszBDHr4Z57KlfNOGCfARzIFQLin7PeK+5lp6NXIaWqNVhh5fGyvsXhruCbt5OePcW2PSpDQ97QrThxlGDbYLcddz0I7lhrIroJg1b4dWrMz/qhG9OKbbDZKrPVWLhlRrb3u+3YQ/5RSUPjykYwRpy1GVIG6LGXGN7m6m6NH6enLXkaccWJ6SV0ImWm8wQzgHY1uPOi8XHAJ4adDesd4FaWq9Cu/LTmg6yb+9rheOieuKcJRSVG682zDiu3DII7sBRQkQdpbaBp+DVdEwOgk0MBMdeY+QxVrOOJ0UUcrTZZNib3MNKQkjTsH46YjvRrIJN8WxVt/EI7qa0nszove6f0uDbz8gNujYXUn1yIJklGy51KQ5IUBx9zOT5xRnNgTbyE4CqQpz9sldbFbqWvLZlh04zdHzMRK4JrNPIrHR4gKyBRxicTvNL84ab1Bl+9fLV8IOoLE2oGYWEXCFdrOkBrd9sFaln+GJumYr9kUx7RU8ZmRxtz0iyzMH/bNXzfONgsgR7hgrdtZpVgAVF7pha0NKBz5ICo8LrjJGThJAf9Oav10kJcJsv6yirTNFIJ4Ye5kzHjkM3BgjvSZVPoNL2YucUmlmen6ufDAWAvtxWk/JCKpjL6Fdhmo9OWHup7bPeZx88UALhv9asEQcwO/3Xp1sI4Co9SY9lMQDj0Y0RV6jdlfAVpuZpYOzkETAPWUUt2NsXF1+PTDbP4st1HHutwIQJnwb6gJBGM2ZdTi80bJwobcfC4dwiMek4PQxHXayXbRcQqhzpNBP2vhehPPhqliLKyH8jXaQAFUHFo7nCYjPOj9Xr0//+k6bqcMP9wqeKDWV9Q6+G2W+N4BvnyYLzgGqlmcxdW88oYvOToa1ugED7aTIWp2+/vRJr89ui5glpGDpF4OrZ58wGwBLvBew6b39X/D2Qa2lxCgDmGL0hsjuFWslbUDHkXRs3QxqJrLuSMSxc94CgUnQrmhiKL6htiE0bBoZ3Vaoii2Achz6eas4tcP4dZJeyguOmYF9/CLOEW12qIkAYfRcgtXiASNFvpIFJ0DEWCeaP6rE44lOgBAxwjuTcSoXU1Nd6leQgGQSV+qBtwwoegrYzWGsuhoek7w5UOUohLYaaMhqBZIRPukvh4vFUxa3GOLiLi8Jg5PdAgG4mYAA2ZnSiLFumzfqfSyPyrKVGigWMQqA8BM9ey0G4lLcTLCPw72ZIe+cHwZdJgddZW8RNBg88D7d6fH0sUOsfxau3JOvbRM2RGMffTmPczPthUzRoHiQ4nq7g/DWouRofS/hMDmfNshY9mDEle958nWAXgkNZvrkp+JMSUHgmW0vMbVtr9GrLOwpJH2G9//SneMNAdl/186ZiSJI8tugtA5wes6DcDsUv71uu9KrdSdd8vsddN+C4jMDo9uAQyDFtZZDr9Ai1t0cxQRIJ5WUvaPBaWqSC/+aMj0rVO/63KFqzZbvymi+VoRUIRAqUseFtB8+uzJMsiVM+IGqaT0g5jV9h9rqcrLIlVGr2XUEkV9vyzYDtNc5etV9CkWvbVTlkJCkQ5ppDT29FkzFvW/h8maOk3u3yYgauZ4EGbQY7VlHr3I70umb3asf42G8Y4mMBaIzSPlVOjW/UNJMbqOXQs9HCp38tXmInMBM6VPUZNn4ycrV9mylRvW1j4OTE0gQRB4YkPsRm7a7r8CjfgYCdh/sb5AfRNL03bPwAU0VkeZDvkfC7sRZXLoAbZW7rmSeVDV2ztkeQxhiCTkRO3eeaawdujo+5GyF5rI6Qxw5o/ABj64KjIF+0w+zg7q6eKl7Zz9goNV+RdHBAxdlbX8UQJcAmAGKvaY1K3a1DoB6uU83cuh7fJ69qqorjZVsPb5wp/IvzPblhXssbVxAtn82+Z+Q1f8Cpr5aNfNJxWRSQ++bQ30R9l3wzAY91/6LVm1CJgVg3oIx0ZSql890pQaM1goV02+lshIPXrA0KutCGQdu/C4mofkEcw2KoWfopXgfg59BfotouITvZzzqXZAd3v6hQt1Bl8Tj2uPq7uajrK4pjg+G93WG+6R1cVCx80XZnFSXhjAmrYmSeQXNKgl2+GllmpDlhlwlNP4aYS6aJfhczUi1DitlIr62OA2ZcGVZUuGLvT03+xi8YveMwDgq2+cBr6/vBMDPBWM11zKsp7n9yNWt+e0Q3gTWDDa4/wyII7xW9q98fxkPrJfY+Kl5jYl/5hUB5VNvjhxPRdaRnjySQClyHAIJyGyy26GrT/qQtbvbtJzcp3e8UnBR9wtS0DDmfREh2iiFxfx+r9SkgPa+ZJ6WmxDhKoaOAlzY+aIpdDRtlPqJhpOnfq8JR9ic0y5AHtcS1shdnP6rrbYz5PS9VF9W5HwCoGwTOTBv6SGxH9CXVZtwdi+iObFPIF1JynIsOopk2b0/wsyljamiPUH4Wt91spW8EnWEf7pcUP4FrRaRwH6jKrDO38SUXmeK0uADq03+xsmnsBVrUMlYb+KfhhWO2wemeOZQNdgS8lPXX3J+7upzde5gXkr20Dr/6YDwaIGqJRdHpNUG9jxYf3cPiV+XV4HfTsF2cknixo3RdI7mdqFbgxxzVjkrwIfYvvHUGpVu3xPSkZzyzCYy4YttoNcobAe6VadukwbBIQThROcvC/BLqEa34HQZbujkb7WrFXNhqISlP8Dg978YJM6NAQAhEExirIq/+04ThRWqByisGn47zjuZDUenchR7hTYMXJWRPBJ0YFnyzshqaqAsbV/s0ThjrowKOmqUh6eaqHJ+wny24c6o9TPAyNnqrlXqug2Fcp4Om8IPFsKHnRNQ83B4q5ktb6wkfsNITaoYoY3vreNeN2thJUGF22lPbqTz7XBWM27hZnm5HArobgTDBZ3VNXvy+oCHnGSr7QHm2Au9z0CT3SYC8a1+z1DYo1/0RZij+dW77zriNaaPxZf17/VRZ3ih8/TlzW6T9u2tUKEq8QWBHcijX2VZOrM2O3p+4w5j5sk48jEQpXQDowD+IA5/LFdvkgGVEBg2d+Efxet2bZYD4ks9sxSvMxMAyPDYjGMooaEeYZzoh4C7ksILgVWf7vcP+6BhJ4m8ek6qsszQ5BjoeepkGyaNgosm5g64shpMfqw5aRGS4PLLHJ5lZ98kPbDnzi94oxvO5ctFarDHof7GJSHTzdimGbIiIAU+10RB9tDUqs3AMsoBWHd8akK3XHSxiO3LaMCNb5aRWqY2nxWyd5BhS2VJ1qVZjEqFpEr9THEvrmcUB5UGfv6nargGES6jWWlF7JPcAFMm3VCSp8v3FR/nSMBKoDyugivYyRrTYx3oYOITj8VVc89nh4uhzF+IliNnRQYW8voP3DiPZ/B3/3H8vLVbRMI71w7IAcZOg2ArsZli2BZE1FQmKpyEhJG+l4bnDWfzeTNHs340kzgu37rKpHx8wsNXL/46USlerem8epewmac+g8wWVWXdfizYUqIfiJa7XqEjJ56sDxp00KaC7mK+gRw/xCr49s+Sq6n8n50x1wM0A6e+TDVHghaQzIQosSMWzYZ21DWGrjo1SYLPxmLdeLKkOz5hvP8E+AekAsFzG4kbYEl+8REs+/frJ+2t9RA9Izahg0u/kxgu/V1CH1QPA5lMxmhy5+YeciZ5q/WeUdNgk/KvqA9LFGzCt0Ru2Ket7Wv/rtyyr3dM2q8rcXjQ4uDfLP2M/8tOY2m/fEwwdfREjGjcd+CbdecfPW2wcU5L0+NnCIz0QriD9V8eHtE4RIGAx8oNKbbqvla9AxtLi9OHKRzuYbkfetC685SbxOm5YygvOv93B41Imfv52FsTCwHhA84LkIHI40Zs8tt5KpsMrnba0DAQrRTFPkMPOe39ARxgtk0OU7KcbXfRNfAmTp+borw4baN/HLS5uxfQ8m6UHdDPUrv1nD/esdCNHuJfLAoeNX/QJcDRnn3EEfern5W2KjHeWlvj42EhtY35zl1MXJllOWu2VAYitqOatNkWLZhhTObbjqX8bRA2HWts2Z5BcPd35TlvEcGctWXH0sEskEu+X9zcogtQVMCDOWt87dP7LyQ+NTJWN65cTkqVcJ7X0GoIFnUN7xv9kyzSTMujeFsjWCgoNI5oaiph+VdSBsUFFyCbh1b3B/D+9YeEKVZH773/YH7m+1qgXplRjTEuuLOiqG9HMGTZ4kL5TzA1EPubQLUCNUN0jgxtv4Nh/uAW0RlrAOUySnHgYqzKH6R7Sw6NXETiH0uxIm50cSKhQqFgS119Pl/3qhyz1nSmWg6FF8bSeggg0NGcrVZ330Q2J0uMQsjvfkpLhUVJGancMNqWLhpvP+iyGfOJf8qGfeAMED9FoHCArVUDUOsqKdvAJfN4JmW9NICQ00fL7Hgb4HZBQOw0XvkIl6D7arwKyiksq78/u19u+o2Um/GXinM/NvKK48XEjA09BK/uNNtrLJLsbxGEZwBe1AyORfwYnXWViAJp4DeNKgGrEt+k9vfvIfVv1sYntTDtCXu/DNLtCqiEzrAJGpwgpJ9wEjstqlL44ln8MgI/ENGFci8F38B6ut02UYKPI1It8YxuhRdZLc1H42uIDbYnoTNPSaEyAsFl+7NY7I0AzU4SHI6afgwyuzvwqI7S82My3GRn54gGAOSJV0Nr9+BC17atoAlgd8vwKF2F/BtTIk0kZBYWQAvDZAAaGz3ndGvBIrxP6qoo+lHyRAtfyHMQLSQ6u9OGtu7E97tbgF9fUmWlGj8T6EDyuwPCW2pOeXI9qb1HDqjwE0ep/qsfCpZe5aBrBbnPrJWks81mrK53+20CSLXyLf4dve50pZjad9noDHjep8Y7rFBqS+TNEvHGZF+RD7B7bQrcAx9kq1CtHskuUoiIJBhDTJkvzzmkV3nqK+q9kGgDq9fnbmrXySqd3x7YlLiBD7MILz27lY9fkdlp9qriHFR0wToIBrDRkq9/LfwrabIMrrTjh7sMZDdUzdOMD7AYL8wIHI42xJcnkjZUDiu8jhqY3X4N3x9Bfz+k1HLoF4gJL2ViT6jN8eJC5xwoDH8TGhYuKNFd4ZYCZB3xryhNH0zhUdumPEGFIiapGvKjkVXzOMH3ZLxwIMyWsf7sbxLTTsHzBMYmmdT0AFsjEIb/SN/ThHm1ach/fk/uvVUzfyKj4/zMn1z51ahnRbnZ78ZsWojnaElmm43hLPfDAmptivBiu3g+iEWCPU2942XTznAQhvtU8FsogN2FsmiwqtFridC+cUIv8zlgTuPcKJNl6MNDgB6Zn7anvvcJO5D2/NFRiOb2Tz3zyFtJKxu9D5D5R2sRcy6L39xxgGAvFb0wUl6Npu7MVz+GoSwGAnAxG8WEN9Px8jLSiaVvakMO4ydKQJHHXNX+xLXG82uLTaannRosg4oJPmnqjKoIzj5YB404mNxpb/r/DAV/TqiJdSa8oSR/xcFdUPxV9jS2BY+Wvux8BcTiZ82mVKeo82Lt2hdjCZangGNIffekgQIiejK9skdm+7/XS5CbKTkKcjVUZQ6Wag1wTA/0z8wSH56EwSk9KCwUhQ4ivtXtbGbBSkWJ6+sV/BRqs1KzQkNzCAek9Hh3A+SSHE+YgViz1exV1OwAaU2yEC3hvmsWrJ9ZGI9X6A7yIZxeqt5445konpd+eqr77t2JLkg0JFBtL50lsA9ITWAS9COEWWZVCkomRSVS+yVEDt+TxogoncovMPDbwljdzy5OHsG/eUfAR70ODNMg3qqHel4bd2x78M4MncBQVhcP+0imJsmTwEWNAVrNHrV+IEZ89exmN5FgAyL8lw5RBgplk/0r06H/EGLZxG+PjM67lofvPVry5eV4OmD1QNOJv/e/nfHaCZHN1ezn9zRE2Oduv/O7DZv1gCABZzA0/88g+rHFqbH0u1KSySgtTNN5JV6xAw8Kc3NaoFrR5h1Chxq6Ic1wnptAE0eku71Kx8iC4iov3q227904Rg5OYT9VJIj5uq3ue8KUdbu8hMldJpuuEDgg4M2Sz+mECFhe6z3iA64PvHLyJ6tmhrILMtaDRbHvtnf/u9l6NyGaSiFMRCdbh0hdN9BUgkBUGahBpvuHcKTr/kYm9eJ0CulIHMGiaGwX4we8iJENQzizf0B3DIDHvyXl7hKwftAUr+SIAofmWWNJX5w/C6vIhRKkW3LITxAzNoH0kTWSj7Vi2hupfTvaOOqdNQ33klOLEivR01c4ZLcDJZWJr/Wg3jtUsv1ewUTwG/g2rNg9jNbymCcSooC2EDt9xi3nUXWl846Ae4QSaRJk2B0bp3SPn7P5GOwJLZvHRee57DNZLg1dc8mGeChtWnulhLgDZiBiodFyzhFJxvEPZXde9nWFTKZSAoalTU+nOBWqj0CergL2QuNqXmOowzMoyFpwG48OMpYgSAJG8Bf72rLG1WOMp1UgQcykIJPDn0s+oOfC6G8iFcBY/xJARYklyKXX+ZVhRUPd09OMtZGF/OJQucOLojOzNco5UEEWIfd4Md0GuLc0uzWK/G0Qs0GP4hux3j6tueTXknc75aDQiRHJbQdQ9jxsQA+wVQkrCPFOHSIX6Hk57lniBh4iKv6nurzFtgMZlEKAOwdlAPQN6gx9LEieAYYXFBku/hry+lXIkvzbGpad9d6kmLHET6jliQXDh5Wl7VYOSSRzbKDhCxA4oGMXPgQgwYj0XCnnfeXOYhNcXoIOTZDATJAODiCUBCsNBJM+6QlKrjdIOnn57RBIKYZYWCFw33QJ3jazRByuMyVQwy90mir285PMYBA0WSPXd6E89ts+ves2pgRDT7evBMn3KFwCt5UK0PO9cuIUHoBWsIwa1tgpmtSkttzMVBO+hzmyS0Zeh7WBaLCzTV7QZKGYZCkyf70Y8+AZpMNoE7omXTCx8nDNUCyo9KkwhMdyCSL5Rmr8jt8E2DzJJD9P5TNmSlv+nNSXy+DABA04cXu9W5Gq81scFoat/m/3o7YcF9k5vr8QfPmgs0dzU/sDUpyzpDJpE91st+AAIxMeYItRPMlD6B4D6nnaPs4eW9r6sLnHuI2GjNMr1YDYp6j1KOwKj/pSoHt+KXDam/tygeb0g9NF/8t1zJf+L6MNlLAWv65H6FTfJ5+t6CJjG5FQHhevS0Uzspx4CfRz4PQHi0+/xj1Py7yiBFktIOsR1nflsNon/HwfHE66HwrEPCblrZyXBvDGEBbUB/8tlXSFjUzXjdBiMgNbIEyda1RuvrFNBztsdI3fZm8Ey0gTGuNqyAOkbPWNotlU3o6DWIMnTguWfh/iZjeMxsa9iVhRp8irnUdoDkeqIal3vxH0TvNvSqXlV9QIyAWNLxKNza4+1MeCZR9R7GosjQAYA6aeT6A3JLvENDo7tMRmkD5YV5Z4e6R1pzvrctlL2eZ7fJ3LoP3PyOglZO/MMnnaz22lWw7Xvwq242dO0cJPzdd3Fxp2UOijU/l843qQpS09lCI4l279072cAq4PsIgbshz+gtxfXTnvWkVvv6wMWalkhpmN+bnYEz61HiDtUV/qNiHqWU1tIgg2MIk7zaT6pl7l6Dsd7EqHtCC8nZe59trg9ThzpdFB1PC+Dv/7mYBNEWaYe4Ujm9n91z4KiIt4lwyFCYogD2bzTudMQl9yZmqqbu3V+U9z+CX4r2avQguy67NyST6WG3qRHTCnZw05sriXexhkrC5FDF9BM5splIIX2JbokV0JvAAUgjnYHzT2yaUWodH5lwlOOKZw8mczcJG2OMIqWxjwMxRGoxsQd9fJS5V3ugyB2V8pG405v1iVXkJD+7V0po/U+Ij0JsRkA0f7TO90I09GUvmD1lkUXStqc0zVHAcgDV9yto0lG+d+qV39HNrVeiMMGr+kyXJm7Ziarz3uFGOc+hHdcFB3ZsFftaVzO3HIrMv9SDNjdv8bXuiX0Ci/eGlJKFSiw4G6GPFMs0crzTdqvMhjFfkFFOFFkBATyMDHz9xs5eEhEjFMfh7XDlqE2MGIdhzy2cL2mxF4v7nC5pABCDacL/owWlkI9lH59X2RANCPZJUIfC8OqgiJbPIMW2QxGPMQFJKPhQztj0pkPojtSOsPEnkc594sB3yUcSrVjMXJLdhNa7nm4P3G9rTUKaixpYE7G6YAjHsidMlSPOWNfq0XNOi1YXGk/UpCMC03tmG6i+89rNc05W/dQ5RySdTNA5jn8Qyf0Ktf8BUgAJovhsxYOKqgYQKxMVQXp5lV/akfxWpGD76dPt+9xvFXW053COD4c3IRiAJ+z4xXmYlEMNVjcMjOKQiqSOiVCFdlD32iP4DByJ40WndvtVHntd5Ar6gXO2q3m1EHtorLuQEi1MTPkfdjsTfFtK9Sk1WSOdDHBKGSnj8f4a2gv6CmbqeaL6r/fI4KtPSptYJ9mh6WGS02PnjiEq/KO8wZY7bbjAMyt0etQHhi1akQElNDQcD9OZi34g/cRuoDJuTJhH2+U8zuBzyNvmU/IeF/USmhEQk/9QZqd4TdrQP1aGYkdp4sJvh3jJV2RYy61uDT8uq7eZ5srBK3OnfUaF1BL+1R7rQzstI1gHjOTC1lCLdrQZVqg4b4KZ4wAirF4LlB/JS6H6xnZxt5bQBaTpujkQTEuDZrDtV2ixxZsGXCtHmdl97hYU1mQw63sFsnXRH2MDD8O8GYeDmrJpWbUTYOXNok/rP1HNZn+iBKCoDIi7uhfAOdtiR4ezh7PuTm41yZo0AeZ8RO9LFIB5Xicosi2AWF5i3ZJAF15Me+iwY4OMhN1WQuJ+Ypwggkziuh9b9y5lqEwwYcb+jB6+LdUTMmRXt/JUOBoCJZ4As2Mo67qxbvqrV5aAwSUDABvcD+JVYjJHTI/gb+fXAhxZt9r9S6YIopI7bRQVY7REKJaCmesehcurz+NNfHwszV/MFnRgfPkOP+w35sShj33fgXF7ks/fEunI7nVTtQE07wXYJ2R/2Y1HUV5BoSdY33Qm9OCevpw/2wcz+7Gm5i56xVDmcaNFsHD4MR1vzjncevHLZKkUIt8eqnAvnImYyB5Mh5g5O/vF/r7JKNFGNy0Lu0JYtjRWo0TeQkza2D1Wfsmn2fc3aijHUMQgDGS5KZqMXQGGDt7RtLNpIrdTDzpp+klaVSO3nJu7W2EInzkuTALgYjsEqHlUkQvtP8Y2ZUlqoSJNx9errCQB7XBaWY8K7LfcUZXDTwHWdlSADw/5StquT9eQOOzoDgT3n2t8XMUQoXMqeDC/PkRDRlEX1w0B2+RGRs3mJoiikPv6H6b67yrSJWOeDHvGvcmehiT71YHg7CKzc1n0PKpg20aiWulxXy7dL0aZAklRi4Hw/tvD/lMlVrpCq7HR0/7RMIo1nqSR3ZffU28h6spWL/ra+l0ATUoH8Srhtfp7GXROSKwDkcXyPYB8rbNSDH6r1MHo9ArkqZRkfRL72E2LNf0P2lX8sSH5Bw/V3L5XNGxouEITHs+zTEXJYBfGqoW3f/5Z2+Mnvn0te3JV1vLHRFDu5cUrAEogna9GEQ8VnT/jWVXyXD+TjZIX+TNBuQASzx8ECiQ1FgTTRRjtsLdrRayD8S97kaLAKv6NTrLNl3C79aB3chDWt4riBLV7Yt8NfGr38vIMsZqX6tnlKLb4BoTiwbHVNy5yu9EHEAbxPld5ET0a4gpqapSPBC2+Dqh3enbZdDPnSZFS3AP2mHdL9rUmF1tZ0+NYr3kDsr/NqHMpZqeYwNQlhyctYBcwFInWZU/y2xK2NCQVxgvLSh7zJRESdb7YMwPQ3WkOeRw+4nz1IY3Tr9b2kjDRpflQhjodgoVHY/pRiK8IbYMj5TIf+XQaYNxVaP0wtL4G0SyRm6ozWn2WkFwYqUDJIRrFkIP1VeqhoklYN9lS7BEIH8eQ1g27XR7bKXOaIm2CQbMziyjKmm2Tc5hGEYuiTaW0OpsNc7wMjFZ2nV+Z+OPgE7jhsJQMmtPdtBxaklssUU2aHC68Q/Qv2/eK6CKBiw4/jSP48St49nUkZSYNIGmbjYHyRaw1Wl9vHKa+ZOb5QIHsBi7BlGOWQ/Y4CTaVRsxItQZ8ncM0X8zQCqpTGconSnObfTHi2HBiXCXlCoD8AOKutCcTHyBvxMZDki/TWbYL4Xm+63EbN8sjMNgPuwut2RaGMK1LD4UtlJzkEStoX7l5wHPi2afumH7QX53Tvi8N/tw7HpWSu+MRwkNux0pPXUZaQORphheQgvU7nqdWVgEu9QMQGP2U9nYn7POH6w2l5swYsul7ES+qAPMls1ibgoX0tqw33fy+Ycmh3gAfmZ46wiSIgQBlPGGXsS/GphfELxbYF3dG0wL11acq3q8oUXWOc3hxMsOJ/9vtIPSsH1uoZImXkR1PCTt9nVQ5GousogAJWaS0CGQW4GASg6ql/mdrdRY4PVbm8EcXQ8VwReCjBUj3s/Xhq43diP5vZm1fOnKrud/BdQ4nlr6t6TSVz5fvZtTuUGm2r8PFRSzhPB6O1yp3TJ4rD6bVTkDQ7M2q+1LwfMq0ybBym1gyp/LVnbDL2iA1oI0ZxCtSNb2whM4aWm+tS62QPg6XuSldZOapsxaFAFcB5y30FWmlm1l6LnSAD2BaCsKf5j/B+3JUhWh79M1bDVhUvVnQ9Vn8U9nBk7qfV8kkw+UMg8TBbNAoq7JcEebO2dCV9Z92WDwZ9w/66A/m4nTszW1Pqb71C8XhFqCs0l6CBXj0P4t0ckK0mdGCc5aGKuu5zbIVQXcJjSZPOlBYypXJJPt+9YyFe0gfZ+FXGwIzDbG1L5GznCqVsq6FK/DERCO7eiIbow1ZX2CwZ7xNWt4Bx1Yg+XuIY4E6G07W0K3ZMv6f1bQ0wso8uTCJWkLdzp6Bkzp4OBWlKAQUYCf6zLjqknfTuPZvGNGadOueBk6Yc/qA5VUb2NQdkG/57KTi7dPgu7V7m9v4dgS39Qg0cR/fl49fsa3J+tXKBS2dKG0Bbh24DUBsXEclrh9OukpTiQSTfIAg/vHs4AXROKm5Zoi2YEOAQrk76KHtAKfqFjD7WUUWbw/I/H8GbURpXjXEHdsgOx1jdVAAsAGDKFrbxCL2g4C7VLHIjS8S0F6Zar0BAj7l3Up8rRaOgBZ9bvaIa+IPDbC5I+ZN7HWApro7Zlf4EagfjaAzKWqHWnUkv+87ADYolwTYLdwb4eosUOHvrQOu6OBLjCPGS/7zFHVyINHWmW8Jxps0IVC1JheQcfdn6k8qyk1ut7HGetlg5+66Y75x5DBMVuhN5YbrCetdr3sSqfgqB/y/jQBHJfE7QuUY68fxOSilLv2oxqusB+yxvYH7/bb5g9W2aDNOlDgmsRUxNFCBkXh1TrLXqnJsHjPA36wdrOpxVTCYeCKBJCstE685mJwKYmlVPZcNcR5fodedPLIL2NqbtkMEs4zLeCwosprS7yfMMBkd/O38rXBn0WlbeEwpAKd3xkQ3Oflx3R29qF0lW0NQtSZDzNgdhOaOUWFlzO2R0FZWkVH4RE418w7vF+SpzkEdxBLdU8eJ4L5eblgM+TvDm5NshuAOY0l8BncFkkN9Cpe9j+d735Mi+7D3djD/KwCgvSDfYKRa8B/osTE7m58kbmgDfgwEvF/nH4StgJMQRxjnmq474OzGOeLMqz2ACzovKGaEak7l4QKVNU1oUt53AEDkUS13R149Ke5kLrCOFcpUTAoSypE0Rui14KNVufFxJQfhlXTeILapj5BYA0f4bP1CK+tBSaVASpAdgmH/q8KXbIiNu+LH7T3pvKBRb5EWpSK/8Ngkg1l7Xn0il5EeBRjKmWLkrozY0XIE1d9RdHuNRP3gtjYjLYW7Sn2/nKCRy/bb4zn+5Aqc5ahxJXAFwao9TjTY1lZmFW+Bd1bmSWCfvVqt19ioyG0uXuSuNzrWXwHInQn1xAL1MR+dtxhovDiP2/zvK2g7tYZ47y6fLwFaI+NV7txmdwwqsAri5wiED39wCu3gyc7uN7/0UgLTvkWa4ACh9zEYupXelxoLer6DmIOkrtE025cpcyNfik9VtaxxSvsAv35q5x6wimltCuTlboH1Lcb39HBzmuZg8a++HSuPnNAxcArXvQk677S4TgP81wEauOsAFQU94HLIhd5OoQXmQ5Ak3aoTs0gtb4FQ+mljvxTtCR29M0oJdhT8B9hUPsf4Q9Hc+mqwNgLo95e9VXbViLnxwRtsIevmnVChGXyCmNA7wT4KAg4YoAxiui2qGeiVFr6sKNEkExZ9JUM225oCCo35UlNqmLTq5q0EwyUgoScrvpdfEBkOxyh1PRhY8/PErvJUOBT+0etDfN3UKE040BDRX28CfSrrX0RWRlHnLWt+mVfNcVDDV+XO3dKCWxHqFpnHJz6dBG+ZYQShmHKqV1rQ0a6PgEqfiuG9Ydm96QQVn9lIpFl96yhBFutT9ARV/L30o7ZIIOvqKGWZYbX6Nnc0y64BjLWmFNZ/l12A3o8YX0Uo988/KhFI/4ifHesSyUoCIi2t5mmleKaZjxjW2Is2XWGpv/HbwIFOn/6MO8KehUyxGl4SdbGaR9EMDAiezBxBBHuFl9N2mxKSZnz3Y2AIlGYBsKGgodtilcG7X8/+yFefwTgr1JxwSz3YYX+y2QEJos7R+u8SrYGwVJMHhtoB4pcoOXDx3HQv2WRafCyo2KmGsOb+psriotP8q5zvtGpTDSiFARtcDlkKq7rJKnrSeBGfgB/+IiPCRLZd6AfSn6Ewscnq++wKAlK64nox+89EqGb1gQqzidwnMhfQuFJUle/Nbs/e/yIuRFskxbh/6nhwmMWXdD5ycgMMkFa0oQhwCvJJk7y+bLsnBgpgupT9U1xsVOn0aP2Gx6vfL/ZUpmXrZTlnqpp53EEG2qBkPE3Y3TfHEk1UcetvoZlwPgc0+R26R6gm+qhC2EEnbYRli4O7Kv6qtRc4bEbr4dPA5Hjc1HjS0ZNWWXb+3JukfT8yeSajcIfQTbeuEkvy6362IjOiIuIrrJgoHDgQtpsidCRBQq5YydEPtqXziRWO/k7sf+dBPJZ6LjS2YFZkztX7kVMgMn6e9OgdhdVqjdRZzKRGIXGqq3IhBCVVR2BIqBPRX/en+RLM0F4KtnvGZ1RlGjDM0Go4Q8XY+PW4DZ8RnSNjxa+5aJeC6b/B+61TYYiWjj6hgUY2if6TrCtYC1TnmXvcDPikTpSVpvscuS22TF1v2DOnisPdwSHew8hCvwEjnW/CNToiWgqkkuQJXTYDtTKjFIeOdf6endnTKyAe+wWGYsc/eSJB4D3Mvs2XE3h2iz1vyBkquHWQK7EH0x635TtXWhWtE+tFzmoreOJQjgmoPvftYxcosmkdgTzt5E+gHFF1Pgkqlm77bn+6tAt27oNUTojieBzYsVUYKF6z9OaBU3zJcNoLN4ddJSdrV8i8Y4lVY2OuFD98AlAAAAgTMHrg/X8PCbBFvmadGcLlCEJ6nlABUd3bG/o9JjKl2FCuPp+S/uHgaoHXNX3Xrp4JvUrZ3GP47ujo+kqOONPYki1nbfVlYHFBBhqCbaOqNwjh0en/PPTX//LUL0svSnAfAjRaHiLhW1amgj5p5UelN9CTv26S3vfU8UzU01v2JL4MZyqaXxWpBwHTOyBKYvWlQPIIz+Q79u23Jpi/ilJCjajbLkWIQIRvvxdYVTTbWqOSbjhDmxHdo4A0TSdPpyxpYMRWVmepdRIL2v/ab/h0f1Q7Hb9XwcaPvBkch/cbT1naF0B1VxUrxsjkdqvT4prz1B18WB+WJq7aiU2OWFFi5Tv3RU1sRo6/hIw9aqFwbAtLkBCYEQAAcLAQABIwMBAQVdABAAAAyB2AoBNb11qgAA; RlxRvtAddin version: 2016.2.0.14; VarID: 1
