Properties of the parts of a building model (IFC4), part 17 of 23

# IfcLightFixture: LFX_I_IguzziniMod.Qu47:LFX_I_IguzziniMod.Qu47 (62)
Type - Generale - OnlyDefault: yes; ModVariant: no; ApiVersion: 132383237; ConversionDate: 11/12/2021 4:14:02 AM; ConverterVersion: 2020.2.4.0; ProductGroupID: 3; RlxChecksum: 133bc516f9964b82800b686d90c30e46; RlxData: ZN3q8ryccAAOMRC7skG0AAAAAAAAkAAAAAAAAAHsVu50Af7Yb7fCEQFjjkd4QJ1aKHI7SNmdIttTJN1DZeV97Bk8shqlYZLT62ohU899c5/03wYgmdJhMlzX0mSugFmq5E649t7aU50tng/ox5+Gq4brPOKQ4eXxTEdClZui7VBM2fFVNymJzoX+UHu1TAudrbJG4znIKsgM7spIRo2o54EYDPf0rERxaeabUL3dvV7yqsURCpih5bUFqMFVlQhicIJwRO4JRYoL9iPPhYjP1zmQ2XyRY2mDyDQC6fGZQC3aK9sU1zTW0pOI46Pl1Ol6bCEVoDUD3YXU40Sgv6UzD7vJXNlikSlqOLknakcweTPbby9mfOXNBALuIae9ap073jjMn87ecDR4iayfWFV1rIG3dzm1rvcT5xqu8++49IZT//Nq82Gq8HzcIH9L5W4pU2d6Br3RWm3fwI9lnyKwpaCBBugIMMGG2ma6K7uqSEDJk8IZsuFGDc0SiLK9crANYAQDUH/BUpch4yIdEagx3AKFL6Ut8KyIJYY6L/ir9MxDkfPZmU3Sl0D31uqyZC67krkLTlvfQnCo/LE4xcQWtY4yOGLoX4+kbVKkNIHxdVLm35MzsKII4Y6z9Gqpg9m7lNetGMDb4w02tZ/xxXbfGEcbyHTC5T9NbCABEvkdAoz8Is0gbHR0d3hNdKjvirO3RHS3cz0b7jybNUw2rMEdmtHJEORS4nOpjxyHm+Vg6CuYtC/t2aRzKCZ2B7x8yShTRdA1nfLJyDDhZIAYDdOsW2BXgJM/XmTkJbSdv2a9VrlWKggx7UjwIRHVT68ANsVwIlbhi+3QyHqkfSCarknyXOgHBdvJTys+XFdclQJVcVZlHD9GtcFgx0oJHzEMKv4nkSp3NlIOe4YyTTswD9giQlzV8jRevBa0f/LZ2Mwrv/qW629jQwpht2AY/4B3eV5jL936x80o9Nne/S2CFb8Hu21GOYLempB5WzR2qgjxbb2A8fyEEYDWIbnxRJ7MhRnmIHY9bdy7kuQZhmQnpySiS1Gi9fHbYYprQ5PaxYEKuJe45KpxuLkbh6Y4bFbJkS2bu/loxpoTKagsfMOFrlsW1RBsRcbUTkGCz93UHv5EiDWT7a75465GH/7m9l4KrjuCcP1OUJqDBmM6//JJ4uviut/raYf0GnFsbCaUi/OyIUb1peRQo7uDH90Y9yICF//GHyd6JZiMp0DuXcHWBvceU33UXU/fhI45fvRLJAelkDuiL3iXcQnwsdarVy3fDzhu1jyP9y0EH9gVnPWNAoisl2/ahuHgXg7RUQOnTRxqTKXG0jHii8A+sSVBIkEAOe0UYkXUaLXoXDpjBR4+5K5KCh6aRTKDcisjeBkKTnHMm3MTrX8vVqmrLgXTFpvJss1OFKF4N7Px3QB6T5vaWR4yllAg2RlxrdfnqPaigstX3CUTQbPDTJpgbtdCcGA/waOJJ6qyjdzILOCljtTD4KVnfvkdIY5fbdFKqW33JpiuixgFv0HTkSIedpI95w1Fy5E0PBPKtplPcXVj9qctD2XIjj805u1E7SjrRpnTMQhYHqcyiKYsc1YAe/M8k7pnANuwia4U8ai0yCURTJpIrwTHNKOSUjr5yMFeM6cWOAPaBW8WZt/foSp8Ji7FtOOTBn6QoZtzk2myes9im1NmjFxnE2hMPuuBzrRLo5D1rKRA6lkQGrOa9TU30bxbn0B+ODoAlj0hZSgMXje43lnfoH28v37LEZQjEv40zy6FgLpUVuxWfnMdJxBfybQ/v8qZEomgBlX+yc82HMX/8Fo42y5F4xKbkZS1TNn+oBu6cwTjyj0JgcVo+e4sTkz4WeVRhPg7vZk9+eydjSsb+qt99hmRRFKyoLtZfZq8b7Yw0DyE2/Nw9Ih8Bif0kgCExep/EjE6luEyW4/oKcvhxwlNDuV08Rj6COSTnJSNWR5FVxbrRbHwk2I9TKjq2Qt8LDP+Kws9ENbGa5iYV0wlvOg33+Qp8NYSNlePvUwL8kgSNgEH94D0CGIUMg494n8kylAPV9qOEVYFNpxkOMf0Bgkbodlc0ZPkzQ1z1m13TOuwr29z/RTjsJlxDboPHb4pW24ui9JkoRxDKk7ujyIHg+B8juY7aRXeekwzm4qCj9wQJrjuNgyimmK3YAUkyCuySWoCXApe2iMHGO5QdJnHriD42SMLP2dmhAIMoKJZ1Wzpdlkywh1PabOqrS/ceaH/sL6mJg/9JNRynvlQnSM7De3s1RzzNuRtYeH4jHkiS5pNUwLhchWP6Fk2TEEgmcm7XFsa4IY7QLlp6TLQ2Jfpwt9T1ucH/bXutYLePl1069NTLsc0fVwwR709jREL9ZkxFpUadBVhqzI5CiX6zkiMSh+qzwyRnCbdUDl1BFtGoHJe0PWuKPyh4NJoKgN7AY3uS7cL68YsuBKPfw8Nm/4AhzDWraeTFnP7lVUoNbtLzVRpvuAhEr3wO2Yl62+1yc+1de6R3yGENwtZOPhksCs9WLWtkAdCxRT2EPsKy/ypFqGw1dxizWRhBDvk2sR5avFtv3ziwsdTqihdE6EoH8LT/vXYYGBeTzsA50J9lQ9xpM/9hUpTEVrnSZAQmDk2SH2AgKXpbwvncF6NK6TsS7UM11JCZTxLrY9N+cuJR/MRYg6uA3olbZBXYfrjD+9IRTDWJWdiNZDJuDBhdnRVU/xx3qEFSyzDERk+G1yCyLw0/+v/Z2K1WD6vhXsHp1eSsFGxvJBnVLYM3HXX9cGv+/F8gVtpRtxJvhObir3Z31sxu2cBSWG7CsO/JmjvlV3rHrY68DGA1v0X2v9Qdjd8loaX8J/z0xggtZ9lPif52ib0pvX8IlWQ1mru5iL58EuT8EpAvSCd8epsTq42uqkclJtOjnw4/4p043f4GhIMcwJYxegl5JS52FDfjQCPmmzTf2MzfItCD9kZVByCAB74DjWK5IOsfjqYJvJA9hJuTlmE+hUgr5EjqdnrxywJK9GOVA+2nMQObRmHQTqHKQvBtEpf7Z+k6irmdRoZPfC9d678fpn0IL8hNiaY7G/tk34GWqpMBCwr/XK+F/oC+mGxkwvrZ09u9OD49R+pKIQ4ehYghGrqCoiqCc17Mi6PWO3zxPesT7kmvL+azj8YdVRo6ElFWw/yBrf+jZDq/RQ2XmiO66Go5QibyJVSI4hWVd7t1z6yY5NZHxgcTQFH4TRNNObQVaq5mtpIKmuQtXlobVDmf35D14JL2hWtO3BvBrmtjFqCydz0WCwBtd0JqK/lTH7SRBkK8hivE5xlpvSdkDyDINHi2UMMR3CnE5lGJD6zkCbFbS68vX6to03YJCISXna3shBHMHmKU0jTNfYne8FtI05rHthP6bQ/5fBP9v27KTYLCBwdUwcYRtajajKMdq7nPXwtmmfwugwgWNrTQpCx/dIqEOCH86qCZ0CSFXLpSpgfP+GzAXFyCyvTYpVFaQolK2xdysKpS6aLdD0DvPe9JFMX/NnPwN4TM64NS/enRQE57X952WvvejHgQPYg83kOICLNNnmgL/mf2qegS1XS4t6aUB/1sOo4+xPN8yHj6AHNKK53515sBwi8WzMEmN7Xni6L8zJhxqVN5c6UktAssxGk/mLXs6lGbOMqzgPexIXfc7v3RJXTS7S+19heXTPDyciMEPUFfVMgiGJAFMWgScgshRowK6fxRLUM97cFfQqrlmXanxFvN8WuzsflMQoCjRcEsnPSho7KOd39dTpcnVweK7QuPXktQFu9KSJOjPk3kmSigoCmgocl5k5c95A1cNyGBl+3zggQ/kml0qtaz/hi3sqXjCx5/Uqv5xQcincHId92bCXDgWYfOrQgWEOBojzE6OLVK2YcqHy9bplkr0s+8aEpEcPRp3d0et+UpUheImsL+xtuNEHR2nd4PpGsQsa74uFlHL81t+BAzodyilN+vsJWkhqgZs6+0BflfPiBbLTXIJugZlgCZXcWjGdDeExklHRDfYl0AklpLFbKjT7qmnaumIbUcKXY51fYHsNPm0BNptMiC5t2xNQ2eZSdJpHhWThOA689v66LW6XIrJEw/aEApLuYm1YfmcECwGpF2b5LbToqbweb5666lWir2difGW9r3cd+pUy1mcDF282VCLgPsaSFjiOZ4MmS8HumUX9HRL23+cO8y9AcKdOXfroqYOlMvEqSSubCgcPlI4MHe01j+zIVXYSjUXB1iNWRqKZprNKLt8hY4ozKhN84LLP/Qgd4mtUV0lUZd/cce72snMrnup4mM/gqrnr7vp5rYyC/KlZv2ewcm0Gjga76vvdEfkFykraFeQEWgU6HDt6yNVFRs9hxi3ENzPhXS3/tSB75avJIaRxD5sW6LFCCOD6ZpUQLle/53Ekdhs+Mqj8HavohHfkdWY5r+ZLqfAGxNKeXkujUQlIsL1fF+4yZWTsdbzoKeGKoKpAbPjNRo0LjilMvqbydsC7dVygWQkOw+bBsEW1eiUQuzmACVntOtfzXTq4odtTIkemnybMdg2FT7Oq2uOcQu4O3KOLV2XMmozvNiAG/qQoXHxQWDJkIf8qcKaEZFxNBrs37vdeQM/AqpaUKqkIE0UboNqVkMuJ63+4sehiRjTopas+VBBnzKetIG5RHl3AkYUim8BKoqRqK1VORWRARUXAF2WDbDH4Hf0+CZc2Vuu5Tup5cEftmT7ACKXzGrREKluBzmIJMx6y3ssTGXC4VJ6GgZw8c4O7Q7MB8Yyrtd3AqWaIng8Cvg1XwcjBOUZSsX9psUlWmrAqjnH8eRinHoT0Ck9E+WT0HS04ySj5M8ZdMNQbhJ3Bx53TWQ+uDkummaNlDVGjZNTee3cgJBlsoHN2R9MOh6SFJZk8+N3cMkfPNK54yC+VCESs1kw/0bu9S4lkFZuEsWHGQC+Y5Etmy+5MLdjNX8fYxcC2JlYBogG6uqP6CEEkAaEahN5xxbTTnSa1GaamolWQCkyJpYr2N+Yu794wimQxY6VSuWm/cwUqftmmWbB/VFM/nQ5GTbxQTFPKRjSaeY++k+1t2BMo9EU9RGpbmvl52gxPeUjvxAuNgcH5XASRVJ+D3BGTmiFbbntkgwScX6UyL/rSghYocSZIfklxzDv1tvvVOFBsRXUJlQNtFJEDZJ0MSX/3DhaiGxiQP43npaeJmxsITdEyMswlkZhjRggErOBC7ru4qeB74WKzCdF1RPJRYU+GPBwisaOWWszy9S8Q5odt4+3EgRBykGo8wcFQBzPhaTVEcSy8fEo1DAR1XOQ9gaUky2Zv4/iuz6OLnff79J1otT9O/Y0p6wgXa0gEagnB8qWK/dK1u48G2nCXo9wvEGVPDQmkZgXzd6n0D741bLfdv9Gi7u31FuLc8waI32l89JkjOdgnz4dN8HIYYxi3JUTeFy9tpp9zwxQxyBt1E7CWcbUb8NtwxswroJ6ZvI4RaUH0jYIR29dIhMLvrMUlURZ9VpoUhUREkkZr6zfxkl6IVprfxjbrIbVd+l8SG68JG7BGmxMz313/RYyeph9eCMeougD/Y4L+cddgbf64GBYK1327dDx5g2I0qR7XU02KozWTs4iM1AOlqF4eGR8eqDd/naWV41+UrUZUaLDUns8VnR4Ui8yJwqKf+3wEPGgVRfMXHpv/4LK9nqEyNpOQqE5JWMgReTRMT9SLhtqkl8AIYKrxp9NW7ZZ9Da+hyFzhqhfglXk1zWpOqbQlQxA6nsCkvwM3czmtVk3XTBZpQzheTOEolC00zpD1pjIzdf9KaK8GxzN+5eyYCKITrapk+aJjOH8zMeFnK+LsOdm21ZRGmi2CeNMRV+RiLIBk1lFuLj2E5jrMOdaZLkzmwqnJON3y4zMa9GF4n1KGzYKi2nKhiC5kN77reaJp6068HMJRlEDN4VZ6t0IDlakxGD7mGho27+f/tklwz9kubp4gVapJv++mWW/fo2trkZZtbFx0h7wWI3ert+kX5mZHd8O4cDJEDqHrEmbc6EHjr6bkDJzKaYMLNvKJWGRZx5JHzVI6fFD03nejwXPxqyX4bN/O4fG89pdt15mdakJYUNcU17nagkP4bxg/J6IkEjaOWFWUppSXFH37baAgxldXLG5myeaKhBfLb6wFwMW9N1DoaX5BMOaJrEZ9k+jjlhj4FNmqOL8lNR987koRF+2xOLuszEFDOmTQ0/TVFbiFAw5heFdYmWAW8Tv9bWLUk9CuU5YANC2XPwbfz5b8NGi4fAaijezI4ciYVPZbgpoMgFK19bYhj1TSIiIaM0G4kjPBUT2NcRNFtbnVxu63/MaknwLcLeSbhjHprZ9jcoMYV5vE4SaTj+0k0SYf98g5iREO6t2ckFc9tt7+jtZHEzBTp8UhreDFQ6WkGYsfUWGGDwkF+cLhMQeoy+Jjb7CBXyqS3CgzK+0u55hh8IyPt6+V7kd/EJCOR2x1ZRrNVnzlty9wP/AE0zPLiHrRSiqabw/dk4tKvQNmWZI7B2DYwCZZzlgZVY8CPzoxXkZBkH165jsP1cA8V29EnG2UfZf0lPicWsxZztvZQ9/8UAKaDmaX4nnRJeDgYkYR6BPuy8bMByWkH6l6qvFXWPMWnTvzOl3XF+xa/W1+zQDeAI28/qFHFq/wzb4h8PzBkB3Eh2qs7aJFv7JZcMH5V5Pqn4YPAk5/ItRClHyqdmkzgSmPVdknIpRrpPJTqmmzZarn+gUnOVytqzvHRHZTrKF50H6+u246CsqXf3kUql3aIsB4Wt50/b1TaBSBVrZxUCfAkN3Ksy/edk41/wFCTe7TEV1o9z7bSktKynl4k2dt+v5JsvaaFNomIinG5YvHP7+Qao4+ieRU2zOJU39FoPjszk+He5zBvRz4KDKa2os6x42Uv/doAAUCtzP8cn67XH9qY6MOkLwDYyms0fFEkr1S1CUuzYJQjJSZXRsQsWsDvRh15oAFsjdI1uUx9nYmZIoP04iZvYvAVTabuZqdYtMYiUfyhPI0NI1WHgfSJuKNMblqLtXtW9NHG/aOau3VZoiIJ0lbhiBIBrDgvWku3pL2P4H4qSNIRbz2k6IO/F+Yj2OOU4fHdB1xs2FbiQkb3lmYUM1LEtSUI6XFQcF6lRCtdvFkwf7pFbGYlOfaDTNmZ+6WyTmYduP3Wa0dSfJKUCuXgRBPEURLuJC3EmgG0qQ4vXhXhKIsmNoe2mBLPEmroNxqc5aKHCvPj3q7IpLeqX3E5ysFA3V9YXbhbQVHFfiGKRBWwbYao85fk0YS8TSXCW5Zfm55Y3DRQjiaMn4FEHgKfDGs7ehE7/2lB+jh1r/JiauG6lvu0BeIXKUVlRvfLMjXssAsmtw/3ukoPYzSXh77mPbRTlyDhRZz/gIAf4Dwv+PV9T1H6fxuUAMAnho24vNZ9SVnd63C0+Cvr8PQ8m+IKhfiQ1nf6eOoLkrwIx0IhVzivEWS5SZOeDpYaDr847WBBKai5573nruIR9xFda5bH90KH9GGJ2RsYBXTISx98ySWoii9ikdXLjUOXyCTlZ5eMgYO/molXWmO3uPQ4ELmC6efTWMH21sqqMMfNSkIFchQFh4VKA+fU3nXxYogktwTF5Lnotj6C+zryyTcdLz1dJftu+5/xY9PxCuT2Au7KY9foP2fusNN+j99BENh5/Rih51FXRC6E1T6vEZB84iDw4RvUa3jurnTKrmOD0FBGVfKwllZConJtSpFfeAYiD2pVeldc7biZXGfJ1aYIEi3Su5RQpA6ymGPmlUEuSlZ+9euviRMsAJVcVCaexOqlislCVejwqfveEXmdM9K9viyZbicvxhSdjrgIas1W7sK1Qq0ajt1foY6RWFGwkmfOm5PLMrPbghmsia4flOt+JEJMWQaJAJ+qx343ocNSkocOjFmlrtB3raTD0L0UU30pfon2MsygRU2K70lhlgOuxlkjnk/3tvaWgnfPeIMYa4uvpI5nUolvzMX7x3wBl3K8qNPfgCfsFScZ/vIQK5/dNdXopQk6qPP4MhNSMy0CSwedzwFpZz6NHQfJxXrUXuRdKt/WqIMYWRQRR21PqFSoL15RSqoNzTCIz85AhB7Ub0tBifFg7wS/+lvTTBevF/QwpkpptC1ZvX/8Gw/0rp8j6D3tVCjzsROWVzbeamRlvkbxln/zI5xVEy0cTV8j8RRwciNw1UmZ+NsnTVwR5tIxbeds/q9t6AypHMQOe6pRdUayK8O8TEL+VbQbY6OEhAEOWZG/QplnLVve+5uchM+34A6Esdk3iCUo09puNw/yXeZ6Zd1t6q1kD50Cs0jIluRLXt7/AeRDaWc1U3RVB40bDfQn3Mpd9sIR0444L+y1TG6VgkJ8IOEcCWCWbLlOfjEB6/WE46gdE5PYYFjjQPBg4Z6qQcm6Ivd1+Tn5RAfg9nmeN+YljtgNo0c3WJF8P2bpiptC/ixhGKRj9NIKFsRW6KpcVLkxPQ8quqsTgQTupfIDmbTVisB+Q0nnlUyuc9YJseqjs8vIRqJMEPNEkKTSew98kUkTvabmWNWBIvxUTg5floF7DebWB7Pe+lHd23SrLnuaNUOQX6fVQ7JQAsm+FPVzsrQLKz29A8KScpNKoM5Aa1NAaOJlzfn2iLSob60VZOwgV8748brgNqlm4X4jo2Ot2lzbEBIZNPY8RHjnmDUjbBXMauJUGp8nGmiWFbLXbnjEH1j4yB4emVk3PjUrqnlFhDeEFSQwHZelcuBEI9e5ASEhlBbirj0wkNonfacY9CQlUT0ni75D8Bq01OteZdlBXHf8OQdqBRhBOt8BGpNoWEipTVSrNYEiMjnpPDd9TkDGsTK0xWRvn2H1lzaxbkMCdb3UKzme+b21f8eyArKIXOh17tZXfPIjcnGTm/yV5W3amzclIZ4zxTlLOnU8ho8nZwd9zlgHAzCsZPxLNBOTmygQ+F5p0u8i+haJjtkO1WHd9KXFUQBM/2lDwgFcLYXwrqNM0v5G3YToz2Z7qE1ThcL/IbMiJWdpX58GVrHNK+ARzsPtoRWNf4Qx/J/3iwIymOBXJkFIjlpyCO/JDc7fvLZtpSTTU6viC7ntBAhsoCyG9QqwhLgFlIC/wHPB1EJ7c3mMd9ILEx6dyAEsPE7hb6W9TwIMTDY0/OXrwFXe41+biVGXISStEMhvUipbDjldb597n1bleKUwrNFl/zjZmPCG7QE4kWNRN3lNQ34lJV4oazu7xnXAQDzd5ORaL12+YFmX0uFF6PN6BtMro6LVRv2G9XqTdwqSbX0kJ64iFhptr+dlVuF6K6at7pUkB1ADnJgCTJ2udRIkPL4uxz9oDJAU7hJpNZb6kf7RSUqMZrhy9WapEY/PEM/MzF2YGvcyYCc7iYh4NjOZum4dh0uUTdiUNxU7yAM0bYKl1+E+pVivWhTjqr3N0klAQnjMWDcJtQ6jptMplHvpn3RHoJH9599ZmCv3DGCrM3RcpVuH3zleUHOZmCD/54y+3cllXHAMLUn7v73xpWA32whB6W8iCnzABM/KMhjIaTXtZnWhWFcJFM8vr9wXfxAU9v0mSAq2/T/rAULtFY8XEQgYmHxHUHzvGUW9CBeHwiyMpJEENZXygew0lqA7MWKsXtjD1a2esZcdOg2U8/d5ooF3H9y1vKfTbnL49k1BM9V+BSKgL95qONX0MKS7Iy9gZkBa+3CjXVr78hGl8S0YiTozSNq/kfStwcjSfPwwlZKBvKausHAECX3WVJ7ZKhRjkneJHafQ7dOavaJh0NYecYtNl9NdidAsMw6aEPKtBzZnBmfX1XQ48tQSPvcu9GklMLoGJ0aKe2CKiQ4k2pol1WAf8lTvZ5xwiz6jqzBZu181uBBZo4PvxXCuzrkiEogUVjqMgECWnTpYg63dq8wfGKJfmSWvTU1G1qZNIYL4uP2AWKCg/tV5Atkqgg6gWrgr/Ltx03V0ifvRXIZ6L05lf8A9PYjqpvPIxDN4gdX1MQYC3tS81dkepgrAqY17ujDygljrE4Crcnb2VYzw1FpaGei7+/Ix9Tu3Ztn+0MBssP9w5xVNj1fbBtvJwXgFbkJ6GFl2bF+yx4vqzaBNfwKSM6K5cXXuMfRKmiSV+dwUpbFnIBW5KPXKlQe5Qa6gs/cIYW2ntQYla3E+VtN3ogdmOAHSFZKwe6vdTAnLUFW6PuyTBYN5VeUC5ng4nSdHqU6l9jvxUv8V0WVNw9kfliSKDcqyLZ32u7K8FHmcoqWPuW93vnz4BHE8K3dcxJAZ9TZ1zSw6ofnaD+nktdp8c2f3qvFstmkIOigQUpoTaY4gZR0AQwdAwS+fkr1fLz8a3gkJV9Z2KeFFnRfHv1jVVYgvjzSMgm6QEFBVfOHn1mODBQXHsecZOn8M7wipexuAGDn5upuqXnITXSc5WEBeZXSuYMClfvgfNlx9lE2Wa4Pw6L1HyCdfboxbfJEIyyW26UWDCROVoxN6O/RoSNo2vZQCs7IsnxOk+CsRe83nnCXiWqomWKDlXxEG3gwjZHUKT2/6rLgC4j9lW9pI6ogH9Xtr2SDwzt8oTE8rLmKajkM+YkNQvm2gDTndt2wgjiCxI26TYL6ytvQG9tA0kDkpU6MlM8wOmkJl3ttEDjRz/mBYDBS2yvSprq4hVEBB0X8MPp79zVWZkRMasxdv7eBzOMviqxBK/ZTUWIQGxbAYOC0pjzV1Gg5zpXPZF+rxuNZsyg4/OkaQ8i0GoaA69uFM+AP99mO/OfRSpSwodACGY6b7X2pkknE91JkbBxzM1wFwgvqW4plyrdaFheDEAfmT3RLMQF92H0UxG509UuFHTsXPwrv2RIiwI8p1Y2hHvgpuFniUzaZDN0D4SacHdiADTrQzAdOjK0/dk8QGz7z3yCVTUMNsByK8PZJr/4xxr91G/GEfhE3ebWmXH7efZF9bcS23BuEpCp4wD1GSPf3tJlpuSSCm0ci9iSuuKwTO/JyatKKSYB7hQPFdl8NqE4rMjznjcDf9uYMwAagzEC7W6Qle1Hp971SUbQixF+kD6TloorCOUACzu4Q/HsnDXxK35QPSqdzP6nNGrKb2zHRT9+gFQfxCwMs248NJZvAQYertxCGFvMXO3+vZZ515xXxuvUGqF6tsZQv6HdkLK3v0ZU30EvBGga3VnsLMhDDF+6SyIA2mM9N1ezLAfXq7zs3vgkCxgUAuFkJbDa0vEytLPKUNWBlcSneNP6NbynuZU1SuGWimq/zjOb7skYi38ueLCWtG7bwfdcBTBHFKC6pKLBtLSdet9qgfeQ1c8cdwVwPfpFiFrOxBLPCsV6vDxBI5k6ESbzsMEe+9XKXV8RrXxlFrZq9YchuHpH+K0Hlg6hER55lit4WRxNYa8xGvsHbMQpCqzCMUNY0wt1S9GeLd+k9GEztWJb75Ug4w1ATa1Hy33lTvMJVhbztlD2GB89uSCptFQrsc3xDeWXdvyORMXA2+13XgSyPHMMkOOmP63M7LUUDVU/Fy2sGPtXmZLIUZ9LZdrvYOzIVG7D8o4FkYk0R/EH9jA5d8Lq8RQ53x3XAtLY0/zSFKaF55jnKythqHtn3SkjFnVEeIBQp1P+kQvg3fWK+UadDKLk8AeimDkvfpa9vYC0dzU6oTetUizPmxtz7b+uDLv1Ygp2J1FbMm48mLmHcZPKfrJ1ozI6cdcT1dI69wIUKpd1uuvIvvnZH4WpMQr5vEBTLTfDhC6UHSIOyOFE1w7L2/iqdBI2dgwipRIwvlF1rVDp64v8j0WGpMID05GSo+uyc6zM2ph6/NJbjwPYXuVuuFBFi6+3gdqf/+UQmxyHvrGyWtGYGXKvBe5Ki0Wzcpm88uJyTQUAlShdAEca+Q87HdaOW4t62Ldbor1WY7juvpB5aTiPOXrNgqTc1iw60CvqpfpYOJ3kutasNV4W2Pnnr3lbOehMCDSSFi1uGuppGEpkws3hRdQ3rBirU9ICeQJwA1KOiXDHGlqmFnNk1Obd9IHXDKNrA5zssdJsaXI1Sh2rVsSt25dS5gAooeTUjzLx+OHTb9iusWQmBidzGRT7I93hnO3O2N2QW+kppszEO+ST05xHd5Fwuksu0QUWgUVyHEZjnaj2H98bi+v734SB35VfJWedDrJe3wgtCgI+AL2H6FKluV0+LwyWhF19JsoELniURwaR6v+6MBuwwGWFeMAROP46SajnKRMxaQ2NyAVg4PKNYH7v3g7FfFS0R7nw3S6CAzRjMKNK5lMlPWZnizv7wkDr+USSeZtOEW41GxIis+KpTkImxnsQ+dgbO1qvgoZFAAA5ZXAcqvTJlKGYMiZ7c0POxfPP1FkAvOKfREP9Ak0HEEjfZMz8bGmj1xP6xV3wyIF/ZRlattkXE0WcWQqHH3b2Bdb+7H548ghAUftrwgfVQpN2u5gi/EnRQuIhRpIV5CKyGw9yiNMzyNrs0n1nYcfDFl0EbSIYMM17cX5J5aL9w12wSmPWQToJkxrMhbNsxMRPvoxagPZkJ/vosvfPlMy6w2dfFhnHUyu5METBC/cNurpkO+EzQRJ4sfBOXAvKoS6RMi0RzFXEI9Xj3NSuQ32Un+EhxTbJ6dgQAA9MGHiY962LL9pHsHbxaAZTIyZerLVZJwajwXAk8gMhbEpH+vBaOvh/qch80f7EwvSKrI2uJ8gfXAao2OXC0MZPpJiZDn/DrgGidm1fyyrgpf9Q+MkmiE0qNLCpAOPoOrSPbFoTo5bj9s27EhkYlLBkQ0mjsO7NOW1qCphWPJbU/11pK7yGV/VO1dcGa74ULyQG8Y5g4A9kajcXicgTt2DsMS2ey/LVXOdlg41WfDiDSgOgRkOUFWFYWBCprrAYo6tS0fm13a+Kb2eLlrYPeyaH5IwejQnbUXGafcFpqUFAPLn9BLc1ZIWO15easQpsgYZAuSYWLkU1QKQgudZEMEhWL808GqfQ402aa3rz9/KM7T2Rg8cOLPBr321Qsh7pppaXNZg/LcwV2rCY0o67j6I4vzEHNQQppIAKiO6+xq2SW1WY3ll1n138legO4AygWenlk+uu8JXTo/pXD4CijdEQ5UWKsZK+V1eTG6OJlZs3x4uTBT/LudYXT/O0+xdJ0HMrlSZDOtyUFsPJWMXL3Z2SoPyz/srjTx4FmCA4OWKI1EbbuVkYrba35R544zYXQ2V2BUyBkzIPtuplrCfSnMhFzn57q59ZyPo5iB8nUKzfZRLNugztN9rRhUk2oTw0y6VOEnr3ZtX06Ge2Aq8dJtOoHzLuUCb+PUoWgwxCsbe5/hT4uHp0qgVOd85QaL+/05AdlCB3xyebJGYGrPewhf4sNelBw8KG0NeQTBy831ZFFNG6QIBq9KJvvBI8fCp1zl6yigdXxq/TwWD1hYHgZfyMDtIMmUELS4DrmIrJ3MgUlb3KE3n5LmOhGt2EYD5zMJ89f8gpVbMzDSZb4346Xzck6nGyRSmhY5FVdQL1R1hXHTxJKuHI32hnC7BzMaQt6KPCRanNGVZspXcC6Xd7fbMaOw0D+IbEtoD6EujRlldqSDboTCPrdCe+RH/rLA9v1m1U8tQqWwmKNKBzyfZMMo4Hdyf2E8cVqFKq1j8oMjWMxFCGhPuOncztlutnHnzDX3hy9rmRVTFOENN26+PU9kN3nIR7Wi/ngl+QOYY60YQXtnHsEWXAPkCU++HJ921h5Nab44Wgw0s3ecLvIHg0DxF2sxN+sJYP7c896Bbn/Q0onpE0GE/PwP3kAcNxiKiDUzW5LxZyu9UfC+ZNRG0Y4HeIlSNMKfw0FNyfN4/zRYBL/yQvmEd+J/P9QoHEiw1l5wqz0ACpdeBBHvrJB+2dai8cruOP/dAQiFRgz5voKaMP/l8VXa9jm3SdMVTNaoZePWi9zuWo2VGGDmApeoCOW7DhN+lA7o/aPbE92y8ofCHGwb2UQf/JE3MlxcZB8qqIdGR0g0qYarljIftojQ2Ytvkyd9AUDqSZQX06pO1oxi4psZqvfebRjav89dZoiMvLEfUThjEw1oat4JUp3bh+c8UKOo1rc8u+eEiHbMTItG+6PBWrcFtG+iZTcypQ3t+IT6T+aucYaQuEfFjgGDGD4HUOP4Tva+pVKuwGh/zX5v3zRIHTIGTbKgdnPpx/sNv8sJJXZKpCwYE13nH2SF1EbHcKaqheMFHJ8cx5hYCdffPJnu3QBJxAwibOXri+S164+ULaaQ9774wvyWFPerfZvoK2msVlYujMrZsqDvGnr93Y+Y7Mf+QBlOhYwfB7PA3k7SFb5qJLhzD89Js+/e0GR0Z58sBnYOoXuV1QR8px5Ud4VRq2CdRBaQXyD0xrK2+Z4OtWhNTvGax6YweXBAIm4OpmQMN9m0QhGZphWTf0G2bye3xbbGRvKX6OlhlU4fX7NoocS5H3yq784EuQ2IDXaaz7Nmv28RO1chlKiKvRmS2Itx8y6afxg36Nhtt8N1GGvC/uswhJ+DoiMXaqEk7TOVtdoGufrnt2OmDJ0dVQMpg5efyQmuRqgYvizFoQr+WOmHoFoWD+RiDvJ/Us0p1MUl7jr4MuYNASxuLS2k6GmqqxMv5uxBSFuUKd7eTiTPm9ceAOlH+10/NDrbok3ySSr98ZTMDYk/fV9bhE1JeDmJo2qoqoq967LNVan0LAoqFYY7M7zby/COBKnLZ/czfsNK+rgyHM7hO2g3oHXkr6nPAM0p6+Wta6yTrMcwhu7XoK+r2MR73JbhtSwn/5I+AsjBMpsOIELX4xd8MFnaW3TpIMZ7/k14ZYu4OohRcPhYA4k7d0p0PI/QFQuP5EB87TmvW0o+nuAy0s4gxIgiqcYthBbwXM0y9+4sp6sP82UjJGyAd+C/4nvxPcVbOslU0kI0y5FYO3zZg19F+y29YZ1U7XNioLq3zzsKDqWhBzaPn4UGV0np7oaYT79ObKDIRF/BJ2Bui3mnlTMfl96HEwJyUu1b56i8F4uXxireP0JG392f8bcSZXo6rT14x7G8G33topfBizMMiPt6n/fmY7Lv8j8PSpBL57/co4XgVFYU5qqFgKDF8hptlaVjEn7A9yw6PBRH1T1/AnKY4CS2CWrwFT2iTlilAlGqtyRDgWl0iGp9H2ijRlMmAEZe8vTE4oP69Ni1lf1NakqUtVSz+9NoNyrI3TujtIf0myNTNRqUTHxbZ2XHUE0uq4Fgk4Zo3G0N1LKfVSdQ4OOA88KnrD4o9Nn0rKakMefUfeyodQtstt98Roa6yH9jl+N9YsadVAgg0boNy3tChXPsLLDZMoIyxAAVu8v81eFrT8qRBL7ayyuqb5d/9HZsPlVVVBrMBFYoac5fPKYarM/HWuKdQi69cxTPRcnQrqy32CavbIRV32zxe2eHej+T5y1RcwmaUdyLgc2izkwIOUtQ4RVzMwN0+5gRG/NLJrGz0a5L0ZqttoQjymHDHsaOJSuCPwVwL1nzcyxF1jZlWBdlBS1QnhvwZCQwgLlEhQmv1bHlygUzOE+tG4m+mIa1ChqmC0YfvVuzRolBAeU9hmbuJL+HQF8wjlmFEMDPU1Unia7FwMYZuP5ytrW3zYBQ2EOfS/TM5zanOrAkiYDw9r8cQJTWu7gHWovljYgcl/fb7KeaSu4Kk15r5DKkOloz12EGx1vfmYQ9FdH14ZZXBgucR6lUWyeSCp+NGB/imzC5+Fy4CfIyrsptOzAsDX5UK3ljRovjSHN1IY4KiEtVB9EFCBCFKmjFgnQ9F5rCdHlXXSehxypedfFWQBbhGjsJZ3ZafWedpdGcC3MSN52qaoN6/kMooPhS24KBMqeE7Amyd9jlvQSrgBlShPkOcsR6uKRp1jI1uGoErOUUqBgl/N1AFsDZQzPxEkJc1pfscUQ8obxag/iYBpVWmKEoPOjN5MvoCz7BtLDi/nLi1Gn5vu5q2LrBLk1f4sxS+0RgNlQysRYJe2GaYYLnv4RozorIeeaed5DGBKBSZpKSK7yQ3VzHNJ8Dypb/uYBYaSoClVdNtX+fHL5+N8uiNe8IleeHL+styyORxNkKeSFScCm2wPKmfKgcsn+a+snVdLyhTwyRDV5hqPoJZkC2OekBM2PUi19JzDj8KHtEpvTLlQTtiXflqOZYXdehBHT+XFDC9Urclo7AdyySmPZ7gC2YJEFa24XcgwWeB3hANT0uV19Wc1nkkw4mwnATOtoq7UNlaP5x6a7J1ITqR/tAC5JsNd99KwbgNQg89sFlbqgjL3byKDiWgkwQ5HgeODyILpQT1W28GnAR3DQopm9ylBi52t9lWYfYRS4spVYen+xymxdWh2DrLtnb/kUb41dJ2n+R8pS8ZwZuR2e0uv9usmw2b9xDN3c0sDj41WDLV/7bfDfgtAxHqB5tqGrGoXw25/2ZlbNQ+fKQCATQcOD06KIDUqU6o/xpfz2oJtGuL5DIh4jBovozw5excba/HQq0OVcg9MqkNHci8dY//8Op67SemkgZuNgjRIl9dBBH/AcW+lvs3e/f1zLBa/kZrLEl86ffKM4OTlAi/KvCvjMxMqZCs445Vce2gbXqYkJP9rarYkV8z7nh4krAeyL7hVJPrZgNCVylLHc4EnfMSFnY4KqS2BVWJ4gtAkAtKW8To+j/lE+bIDojR+ycAupoyaOkcOBzMufC74REXF5oiZRLfLYR2OeQTx1xciG1SxHxI6xkTLVQ9EH/ca+i3Dft4Du+xP3UMviKylUNPcBCFuTnpa9YsaGR9weC0tMlOAS/+xEEsqiVVbxFzz27XT3xFivHI5vy7SMLJLaZmR7D3BADiLS/pltdiSa4V8l9NLYAJu+wcAcMo4hcme441NjzMQn1eaH1vNW45ICtrvV1A6iZo+CRP/x5bZM5hqWSUFVjky2sleAi4hqwjDfM8QKgn9ia+Az2H0TUH0pwpJdj3u78oNEGaylTut+kcOujFgK2nofhJfocClotOllicbV6O3JlxU3QMLHwLEiWVhsM9SdsUQJl6BWQY5lgaPiwmGFQ4K3Gp3LT7wap4nHVhI5B98e1MODteUDHJrzf0eJrNEeI5M4Z1ZkMePi+apUQ36FL6fsSQ9MVVOOVC7j38wiTPXAwXYRC2wBgnIchCFMbTriyf6YYktsX4+9bdrgpS8nbVaONUjzehy3FDOLhnJ3E/XL0qDP4Kj4sqxMJMsteot0jYMoqrTg62LgATHjAhs4hdfH1ZuoEilIZsMkt6ySvvsA2ZonDLAviW/8GQlFfWT2M1nKJYHlIz643FSNkSLMYHv3IbjTtOqbzv8imrrUXwnw/wNsi5t1O09TWfLPgiPOeJWbAwXyxljbiJ/U155VCZXNU26zcCQCX8r42i7z8nVfA8wy7O7tyknPWTzyPj6Uw2Jl2RFil3Ogtw2GQ61lhv5tu59yfo5fICFny5sdvPMyR95kqROTPtKIv2oMSWFh21mDXPmlocxiewKvvjWAALZcGnrgO0JlHJFAH1deLMFcgx9B9qCskQ8ULaOrPA4MQcT8LFmMUvpyJmDCCLTN6btr1t6uvFPSuKd7QaVkMy6QCJVE19EYdLbqpttZ05tBFu60qOcOdFdASlynM9nDVIJwKhpxNm9eOm6BCxvggN31SJ9pccqH8fzP32Tf04KdyOBC5moa027bWqTwxGIO9dfI3ZN2sbMPrKt/vwnccVBGOjUf4sl/pdcEwF+oTmlUs3/BXvJvcY0/vucsYh2hwHasrgGwoyFGcQOtVPqoy5C7mTVc5yZtlkNBwI2BIzJ/r/zmN47jDjPRjECk74C0r/npg+MRMWZI+s/+szEQRcmiNtDh//TMisf3Y2G9RI9KUTIqOQKd3VqdSQ2D2KhZ1TvwTqtE+DY53a9a/uXX/PtxWGOoy+5g2s6VFKHq3bkG2/i5QmlDWqY4lwtHwSghIfU4YAZy2aUp2mVyY/Z5sib3yj1tC2G3j32bh162AXMjS92pO2yCsIE2QRY2/ZULGeo/sGdmiOQuWj03WKi7dGErZYfG8/f2haVeHM1LNlkyTjCy7LkC4+P7sDIi0poFTkmIEwt6dn0VJ70UiFe+YfkoFVbGBzoQF32UNqh7ua0RpZjjW40Dr0I31Oq9a2wnBzpw/pxzg4JkTFtlbFmTojdiGpQzq78sF3LQ7wR0C1meQR3r2I6kuQeyfWpl8o9BJP6HGohQaQeqyC25WarVlynZMTZUOOU9C50x7Llwej365c4UzAHeOltwhiPTkZD35lelQWXNYi69rW8ZQBpjVLT4CIcZXPNrSGxl9RoUnvHFtbHiDUic2rtA/GN0gBhg2my6cbGwMZnoogefR6/2x7YgPa803XwLAl5bYEimyIPCEf5Qi/aRcEY7vKITCBx8iqzvrN1pAA2SnAcfjEsrAmhX2+DeB0XNvEPxVFmPjpdnf9s+LSKmyWSbaXpxfyrhigvUAjooy8uwtzKK/X0Gt1ebQUGpaLd4SoT5cXjiTiLTMDODkBKGokzZ0L2m4vZ7ZyKSuQDa8eqVQt2oSKUGkOilAd2uSak/YvejN5x8aMV3hb7Jfr69EQ2ERaNu6e1Wju7hnZwb57g/tPH4DwmChEVd2IeTj3kxq5DwvaaBVqzKNr4mn6iGKeNHZMd7ZCeHmqhK5H9MDeP1zb8kra40V83Obp8f7FHDb2eQ2i1MUaW3r5Em3xL3m0ybx+45XL8c7hEE2ZhIjoirVlpV3VCdPL0Pz6gIc9aPvM1NZubBt+ODucuFx8zzFMLm8os5ImCDDALkxpwMWivGNwwE/VQVxE1HbY8tBcST6+ug8nQzzyhgru1EnO/bDNMHMUNitPN+2Z95+/VOy9dnLp7KIqrHPpipSwUOcyuKg7PVGJQi5jQqP8AYUG0STZMiI2jph711ghhgtEB3C9Ee/+P7f20Kd8dWB/ov0SL/BYSxyksMxiOPF7o7fPOoaO1K0Y++V8WUnbCEzL+JGYyQiZoKLBa8bQdNPNMNDZ/1ZsO6hgFAJMbqo/XtTPsZuab19bGUOcscEK0gRw5/dE08yssLGcRoIM+xR9AiNidiQ21cqyKW381QWH2b29M5eBjkdQygak/YCyLg3VHfCMCMXH++NrAWwb07uHrdqCLMgrusVIsKANdLwVBL0U8zWbKTKt336jtPM+/dXA5P2FUo1jCncLXhPxAjGSu0OQtpFXOB6FeBLbZnhdDnWKqtobfdnva8k2V9ZVnKGIMi+W/1dCzeAiGETQqFcJ2QwG1E/OUlFEog8wFObEQMnzrNRYVJqk5yYovZI5lcF13AaC7XlOt3IPdiV85vyyeGp/r8R1QBlWK/cp+mcT/WG8A+3zSG4+u/yrPsMw6vDN7b0s1XCfP5N3w2gwaFJ0xaYrYDDQo3bUcCkOs90bcdgq/EMNXrW/xfAptzi//SY/5Gs8dmn3zLgyqAp3Lu3ZvvnZb/UxIEXZe7FJSWHY/x8RuSo4sZajf721Zhb9C0OzwYRrugKhlOqNerQyypN3mLPctAQmzx/f9wIWrj/zbX+csJDGaeUuQiBD84mYeHuxRWcatXwaecd3CfUyU78g+tIqfNVw8eRalnfD2HSZgmwg9vpEngDTS1Y+QMWngwowrdx/KFkvLo6U/ej2afMjcct6aX+VGSIbU0kpSpO7n61Hh4rOjdnQF1xeYIMShAHEusF7ltWKEmuNJpqfoZPd3kd9NJ8Vy19z32UvTXuXqNpRYeAahwqExZ/HoVzpkBa8Cu4RjytvezjqYE5T1jbKbiaOVpb+Xgi9u8LdAwf5IFHb0SqJMQLqGaOn1SdSofr+Fr+Y4V0JSHZpBRhv0NdXJJenebLrd61eLtTmjiGtf4uYv2E3wLGw+dK3PW2abtDqsavSvgqtEpH9yBoMIRZy5H+JFeXo4I688lUki6W4vRX/voc3QLJnp78hmrZl2/nO/t4yxwniOQ42u8kRU/AuCnYmPZ19PAd/AEdxRWm79K9iiM+kiBV6PYkPsRh0MiIBxiK2JeGYYMsgOqs2Yri2cdRgxrbUFU/IIAgnEizwHY4VeJjlgUX4wtT0o3F8Q6VjTltM0RROnn0ZLdnf+sOC3nHe8txIVTJCumrdl1EPYsYCXGRHZB/17iCTIbK1N+LGFBxa0gRZyHKr23bRk+zP97G60Rz751wQtgB+9CrqMB6c7hW6kvgWbTNHa60ld7SaWlyI/M3SMVeywBKVUhhiBKgtHxcUcCyC9NQYJZzx3HjFZXnGf7NeKKRrl4R2mR5h6jIMxoLIfxckbAO5tdfq9h25/xMuWGIn2MEW7bUsh1GaY/ktoJ5cIyVFaOKDv/xU5DwXwZalLNFkEa1hydR+oupGFpIp4QpNeAIMTeNkfbMSj/tWFg146Nmnph1fvLPJW/ZOjDWvHT2wCs8WE/LvtOYJbW/HrOh91RyyNeLQQUhGIbQOp04fQTDX6nHbsPNUi9xTN55PUKXBbcTLfKKjUhVlFpb6zHKJuOIQ3eOaB1CzIEo0DjXemhzYyefOMW8VJ7PS/adccz/ZuhulCbQAwxz2sMxw6d46Wc+2MXfP5pjOB5aQ5HKcK/UETOATUGyjA7ToROEYsWHwpvn2yLGOUHOUkonljmzKzaz4+PBzPfdNjHzK61NQxk3QHU03RsUbWxnqDHtU7Vv3NQokBp9wY6cLiWOlIO3kxsrcriSIKfmnMmMfMjmSP+CLzj4JMU3JfOVirP0pZ7C6lQyyOiw9IL3noYIl5latC0G7pDafWy4l/S96RUA1z4EUTWzc7Bk5qNcyfXj6uG88Vlz55DKyOE9Q9B8MuPpM8r04XMgJr283B84pKPwCIhTFEu6gIqSJJV0loiZGU4g8hX1YdH+r9MeIJS5Et2/nPcsdKqGxEJq48z5/1AXjI3imyuXM5acEDnB+ldEe+zm5HCdlJ9EOv3AKuUyY3znSn03EZDOdZFFSEkEEbYntZpMsz79mpuV+e8rXogbJM343lIluOiErxBquPOqH/MepCOiHakw+4B1Y9zj2NVg9McerRK9uN/7wZM9FjZqfpAvDifITGl1ceNyezfHQiieOxVNMnw3ebny9yn/VHPel2e4VfnuIiQGAhnlwF4MI7hxXfCz5KZqInTxMRdzD0XKy0PbKc8xGuzQgxIeEC5EcbGu19JDvSulm1P/6sxNcJuEvTgrx1iL+P2kkswmiOtM90ibv76zrTaF+QyazC9J7/pdk6TfcmhUrytRo/HR8NA/palzlCEaBRfDGmiq4L1ZQCLgDWiWjlrnwStkbMN7QJyGYZ6wa3myPLt9FKtsezhKaJohuo6yAo/+Z7KleqqVbV+smAXJEwTLdqmwikby8SPYrkIvqPA4MJfpr8aeMJY7yhS8Ln/XRHMp1+T7BXbM00/6vIRvBku3CkejEYLA2jlDdPPe/v6xjYilDdrgw/XDhy/FShu+gP2er/abeZopDWrgS9A0YetFvwkvLhGHhfoSOl+xlie6zIYi2fTEJZ8pBNTxY7KiRXxVXdJJ1or6rfq8OqHUzMWQj8WYll3CAJQ2+4t6NUDW7cRMcvDyrbk9jjpJnDywBWkfdM1wHw9UimurbDMvUMR2r39TpNxt7VuinuZivR/b7vxGBtb0UYAnzxbx25phbDAhbnkxFAK+nPGH8Jp94yeIX9pTjVipZM2JVnrpw8hQVkyb9B5F20f+9gn0vYGyl6qxlhkN842qwF4TWc5032pXbUXTM0PaBHp2kEom21zN3klicqXXWArhB0Wi+HmCy6n0ii0nJFDh99bn1x4+e9Vxe+oePaLp7wQXiymsoE3JpDD5ZMv70VOGL45XnzWQfjcXsReoSsaJ3FaxZ3wnxkO4dWvS7Xnhst5fxexQfH7J703hNYSpth2OUywcrKV6ABSqGvM3Q7Qie+9Jl/oBdjQXclAhhE2EfxNZI9kW/koyvznsEL4tz4dxJ4eMkxnEwa/7Q2XnvW6Oizt7aY6+KN+XlJOYApBgL1O4QrMpfGrkRnM2QUGj2M5Nw7ndgosS5bxwbACACE5adBLosZ/gL+bfaa/DWL93QCYm4OWpEKuxljVatiOG53fNh5IKDsnc15SfZ0p3JU5WJfnhuc4DFl1agrjWSSgeMwReLF5rAxC0cTpdSINJFaa3K012koSP7fPSEOB33Fs0H6IEpQlwTxb14cCmwSLjt95DtN46pfSX1o1CAPcc1HH/k/Lw2lotkunkiopwbbpnFpaILadFcrJx4qPFDK5/13MezE+CQSph63PPVxfNBLgwUqyiFti0VZ2wp0BIveG37WMmWotqJ4JExvU/OzVaDTgJ/1SPYjojGtaXqsGsl0XP8h3biNvc9HKjplptg1UA5aC9Sl6czQNUoJvY0TUYmiR7oxZhOy7AThfsAYdoE7KG3EDRQvnrzs1ccNZJg9mQl7yh6P91WPcZHDEO+ou74X5jui1KSzXiJdOBTTrK9oh4Mo1YAya8hzkBN7He/yi6conre9N69b054SYybg2hVCEdeNYZu6V3RFVhwRY3dRbFCJfvTcRN1tdMg+pDJNc2XJ7Td3cqFfFpfqinZ95FdoQ6tnzFtpi3xtGk8QvJqSDbAk0n1g7Xed8yZqpyafrDjH4OUfDep/xcweVboFhv+4KKUbHfh0t2HzlBmC1r1qaKlogQTE/WtFzp8V/sp8OBT8vlhhmxAERHL3aywgguAHAKDu3vi3JW04VHNfgqtox/3Mi0wF0sJqw4znMPPUVtoJ9CcY9lUqzdqCH3W+hABndv7IeeqhOgld0YwkFcSwuhzCslPRI8ZedBhxAkLUaQ1NTeKm4v+05KT7EqsjERxAFJZl1usfeAtTn/ANYkyLjX83a2oafTzjmGbZNSbjlr/hNAFB/XA47FzKeWVEcWKjbeyOpnegEs4+bFXMLpEgKqdHFG8nulLhLpOU8/dLOeRZVlvwYKLcsti8HR+GFDFnxFXSXMDPeCZ8GHd5iVOJzM3U4Zn5Y78ByYg3z6hiU53HY9kDVNYwQigJY4VUWxukVZEkSsmmhZ0troFwt5j7bpBRIHG1gG3rfv6mhfZRLIG9q4vo5eCJx1Ml8xOXdUYOnZS0I/LQBSceHgzKWWXbF4crlhc7V3EhW+/WK5AETvb9H5aE5FJCO44WPfTJcfNDhjm445rfM0bVWFuUxpRRU2RDDp9n+Elhsp6iyg5ZlAZMVoGpzhlI9yvnmxa9oUsrREuynDCdCQlQQnC0fsMFzCuMe2OkEDYQXudUphfBVIegTh8JoAkx563TDeicgeDQsW+dst43LVfM3pXroGhTAnxuTuE3ROivJA/C/NY80GSwWw78SQhtGpBDQ5axbM9/aqiw3V6bn/KO8mfUN1A1L50up5k7oK/4uJz9P6DNYDZxeW4/HhpXBgX8lBAuNJixHVBJdBckkGyM9CkJMXB+VmFlM3tHLomLWJyMHBci7P7sFdbZJp1GJG6lFhhvHV3nEEXTRutuMrs6sPeWgIHb7uSIcnMK0vbAl+64ikUZFBBt0MfY+pAzvY8O/ybev9/gKnb6/AciUMqUC8mToZbezcy/HReB7UePnxRsWxCkrVnnK2bnH3UJYVD5ef7aB3HZ2Z/m5Yc3GHXvRHOIaXF/xR3lvfwdtYcD5wreF+7C4jfP3dahMMEX83Qcb0P2qL2HEbOZUk5OdqaN12vBj0EHCYX07pdRXkwHrm7PIWCo+o6obSwdt/tvxBcbJl5UDvj+5YOzSrhWhk1xYHFSEOaZ8OQYka6rGiF2yWUFeEOP337O3mNFzjUq+fIth6T5p78IVnggZKrkdTvjAHTvmb2F5tdU30PgpqZ930+KseYrP2ozcFYIJdFDz0RMkPOraz3etIsvSkqh22Witd74LCPgz1D5mD37iNi0turpLCc5PSezOO1z4GmVUD7U+isjJzNmIyn2xB2dQdfBmAe8qHl+BcdcC0u7jkE84FomcahSEBGQDJ6yQUJWMrXH5KjuWP92iusB5K4KYtZLyDG9OUk47OaljcS0/J0oT0yvUmme2ISvjBos5Hf7sp5f3XSUSvPj2xtec5Jdun+fzimApQveYGTXj9BwH0MeQOBYSkY3mh+hoKV8DKKpHCgGrujASqiF+D8TEONojEpFNcHwe1USpl+l63MHP57GOZ1TzV6HLrdNFdhhng6oHwoh0Jo6ngtBr9x0Q3BunOQWYzbOtpAHzFWa0WgZW4ua82suRC3G4F+Rr3qSmOY04JmqA/YvmvCVxIDobaiVuNjQcqYYfq6T8I7SOqYAgIQm1J5Ini21rPBHX66L9rrSGQfdA7BpWDgVzLU0bmJPpGdlTo7vq6UAjQL/ICDRkwqok8WYPjIT56e4TZlT795YiggDFHHObWoilpDXnqqu2Wfu1fkHFu93RTdZEFU9gfgrVEDJ/09VBPmrhqffBoYTZPsdDK73To7BP3Mjo6kXcUnW7+dPnlD8Cr4y2uO7K8nAG4aIjyU/zdeJKR5n2enkDpe6oWXAjt1VHQEM6LZxBM2xLslwW+d6s5X6Gwbe/aCRcV4JkUD1uKydtw5g8sM1jyGY8/9DhqLsM2UgnxsGr0ZUFPK+QolYggdnF4hCFULF7+QWMWFTiGDhE12eBKRR+p/nbhxfmrFtHGEbDBglYtgk3QyyYc0eVAkYjorvcDn1CMQZAaTXS4WLE45KuQSAhOZe7bfnyA6KebPFZs2LK5HaSAAXF9req5MEnhX7lZi2FLu2bL8pPWPQGtWVNBVFQ9PFAgaeJHbu7ti47/1t34A/phkFD5jSO8eOm1Sxcuo4t4qAKQmEkR6FuzM4TEnYL3y+4TVOYfAMR1x6XPDoQOT9jEXXOhDSaS1HWUk0jNvtB0HybXFrCnCIvRzEDWTR0Yu/5od+iLd3V4gIThCSKLOM00p0RzEygtJy4Be6J/6OqCNvqany0l29xI80JkvoJgCQJO2FHa2EKzriTGNPSRLtsFqTTIuonOu1L4H0IeoO6INWiitewh0tj3RolLzE9VbAvIVLPzv9BUcTKCkOiMLqz/dqJvYOsfhV8kPf7YJ7uXABYm7mAYGpQOTasxrP8cBbztT7RMPMXLYylR9Jzo/YRMrN40XddSrehU4YfMy6MK8nm3TWu8GazI0jgZ9KUcHYFoLMB0UM8Q56lZ7U6ufLvAu9CvZIuL5anmFmJA1WkGQ6C6Nbdp+VBtcm6uXj3zi/UtHkaK/MvEFwjBNQTLr6RJuCvYByRAqfjEQ3ZcRvdkm3qZ5Yj9p2+1p1TCwFDNT5mB9j49XVqehYtkqJpTkaY5OfJlIFyC+xsEa+eF3RBRP7vgxuqWUAiIFObDxpiSo47FScBSvhxkGC1zeQ/mniiNbSty+qbOnOXqO5gCgyEuO1dTdxJg3C8ntIRuw+uOjthrGty77qfSYRVJ6sUWnd++3OW0Byoy1g3W3uloU5hWQ9Wzu8+Xay2RUc5+u1/gSTILnWWgyJSzNR0Yytgnfxl7vgS7eeRVIWSpu7PuyFQBdGW23EFRlV8GYZe1pUM+NoPKx2eWApgSeqsmT+N/A+YdVNE30ewRfxRWdmvpXNsgbEmyz/h/thodzkJ52qQgusSM4SwhxGVSRGSd3w85OJ3w+Kov31o/fKMPOvLhaaKp4Lngj7odKUIhdGYB9fj9KPv23qe95f/q47QbjbBThEID8u9cY58KsArT8HoJBPHjvdFx031dbLJTJNB+MLB3k95oxY0xIzJKA9u1k3XHdkEi9a0skN5SWU+Yuls1BmsZCr0Bb6cbAsrDi6vuENTySRDvsH3AylwtXkoGy6lHESo/auB7EapLVBy0W4kElJDFN1cyg9gsqh1CTJCnTtiljLiNG3FzJIpk7PVCRBYPywKzjvUwH6sI6EpT9gBe5quppfdgz7u6MMVcUnOAgkai52FnTm7gJbP/wYg5x5Ddave8EqhbCx9NpfTGf3vafMV48TBl+TEHEzDXNy2kdnD1RW24Tpx1/j1nb1ghevvFw8X9V+y79S9sW028Er4B0TbHwTjdEEUooi5GtSL7VwPdvlwGHpAqHcYwZHk0uSnJKomdGuPg9heI3q1u2PgUuIpsckqpQEEa3LUoDPT+LOlNW9OSifBwEzkQQEAWbH/f9s4KhclPAoldO8MejZm2YleUh54boERx1cxSAOm/bgyaGMKzxZIDkvCoetiR4UwbAdjoCBhesTGd7TWo3+ubbePT8u3WucXohNUSbsP3ZI7FfzyJkk11BLxwgn3GhRar722gTfcxweBXx/FVRfcA3XUqTUiktNVhXaPEzN33jR9pvXSU710+jejHJzHlwKP5nA8ZIIO/n9u4zBHpzB065RMyWrq4sDtQe5bFwIZR8TLYk4jvidVsw62HHwJJ36ld6NaJMtI/x6oN2oYn8AlRfjbE7PH/5t5tHAyNWyh2UXg0UDMP4dEGyV8l6edT5NdFLStxmwvitzCXojeOJ5g8bThv2QAHga6WziAmYM/25G2aAxeGCzRaZZ7SzURykyeD6RcizjUQDjx17sLce8M/Xc5DUJQMV6GUOjFCEend86shIHLSTJIKP1B2hPCi/6LmADbkMCka2raDLmLVME+cveTtyp8+zHHWN53sXbZ1RKYzFZhzG8PIl7PORvPq1sUt5W5fvpJ0rdpRoBP6N8tsLew935WsI1CwCUtlclQ5u7tu21AlOrymzezZbcmfRrlp4rReV2c4Z9EPNIED4LKFBebpb/clm23g0l/IgehBJka9OUWEgCI8pGoIiCBaIBh8ecAKtY7DmcftB1lY/B4cVCLVhHypIHWwGOhsT5aE9bKEW6+QT2YhDwa+aaBv0ZwmS6NoJnyw2aCxg6fNC0ckGVHQ8PPMoCUrK7KHNnqMf2BwMH4NrP1r/lIkPxe1DZd/kPXZQPxcdDBA18D/HMVKwdm0pSLcQIVwTRPAWMmRkdiWSQfnTWnqMlP+1pbkUImU2l0UEOP0oo15NnIsGjJdlJPQleSrmHxEmDBaaOy82RwI9ZXb2kyIOz11qPl2xmb+Hqjp0ImuuRUHMhDP4MOJ7BbvwKQaQUSSEaQnNbYrGmOXLcK0JpzAJvup7NshllpbDHwA9+rhJ2cJxND03u+P5Qdw3WlO5Ht7UrU6vQHBAFZo4ULzLXQfUSCjkUqdKFHw831g0/ek4IG9QaNLUN3hcEa3aV9z4oZ6D/cry/hms7amqWBkQTYhhHiwUZFCLHKqYik+UOEw+A9jQW2y+4rCiCSSTVwtkEPSr7iKsJ7JFEMyTER6ro9xcTd0HdWottz560C1FMlyyezhrvPOYJBSCjM6lMxDvOJbkBFkRQPe9tX5NyM+HHhVb72wAB7b8NHQlxDuxqV/XQe80Cluun0lxnHV50I13PR09QU9sNF9IJxxaojCS9yA5v70HEg0fk9OcikGUxR2cWn6r17ILFKcTgE3KS89yrIGnPkB0iQPyK6zj3hp4LgsO+0avFwB16qTmWr+6xTMnydGu/bB28L97LYFYwA4cf3cgh1lznFCM1Up8pwxTh3hJTDEijEi7fWRK2flGtthnhOoblLHIUdzpx6fRGSuxa2gaaY/wTS18KQ7UL9CGAv2Fs1DurKbBScYrAM2fwlwHMYStSDuTmhcw97++9BBlCd26dYwTc0fUZSvGHQ+l1apXdcdSbv6Nrq667BpHPDORRczBc1ucekjpIUr72k5fja4IPfEPmEKytwE2QgB94+PWWwFkNEppzul2t0cyxHu9ssyOdSEje4GPbO6ExJVuOPYwKGpaDSfpITECh+pytblDtfDJScV898wbJDOTs7s5LVKsbUSW70o2b/haXIvPIX8xTVitysbjADO64Cc3VsSamiraz+1KCS/yK8mIJNLkKSqoDYhSV9aPzabR/SCYNDLS4kNUOYZpOzqZChkE5JiPple2IN19c85Rx97C1SNjHtaowBOOJNVIgx+v8rI5Oi8JDXD65ve1ms15FgfszZeQofk6Lcxzthwkxczk3MBH7RCetONwDZVPoLwdmSjM1q9XfpVinRC6c6STMMXbm3riSxlQjmOfxCQi92aM/O2qkohSSrojjiRNZB5uXHOSFfbINK3msTbhL3AS24Ub1Op7Au2PlSbZCZaLOapPUrSDfKgek33tRTIzzXtaOSkRaw6y4eeFclPZs26BcB9oSZQ9eP1HqmycBO9S9wwFJkWg2wPxshPpXnz1T7pYkvcAkI0eZ2Hi1Yurb2YTAbPFTYNp9Y3cXE5Nvs/1iPzsQSAlTpieSD3n0WdS+RN75rnsUbTQm/fJWmAEyRhQIwUl/HEshmRjkqiFUlwtKjmlK5aCQYmiF65xxiICtjId60mMpCnQAJ3by3gtW/j3PlaFtfgzTOrOM+kEcABOJRyP+n7Hyl1Eic1NmizKZo0iv5umhOPESjBhR8hWMVuaEQI4ROq8U/xg2P6rMUl601U0nEBrTVv3eBKZurs5BXESrkVnCf8N/Psum2+cQeY12dDpolp4GP6ElIBquIY79C2gSM2MsdJpkyJSSn8qD5tTDdLCgq98yjCyWzHdUsx9SM1y3MTiD7KShYlmwaBrhpI1YgYUi+Yq8fzPG/s9mdN2u9k7A/Pvt3YSy1oGWTOdUSRxDIKwzwNSQNRRiE7F6yoYyTHDXH+4b0/aeEzYfXYoJsQE3hGSLIodsdWwpTYbMXrE0cYCqddnTGfyGH5Lk4AUd5aGK9c/7OKAU6sj0hbDj+mpH9dFjeV8rLqQV5u4S6hWwThodmsakzHuJ7qlWNf3akuJf2RU1aMAtFJ0UkYPkZAzu93cKyTNaE2Xzlb1qC5Cu9kk/NtcGrbe6l5h2urga9RKjN/W6B73bIji7QbfkVPmVXkY3iHb+cyQip5k96GpcfTVmpvc7Pa65v57fexn6taqSxr5PIrReOLZO3FPmYpiww1pGe+KNtl7XFntfm4PPV4bf3FXbHnh72hC6F06m4o7I6q8PZgtGZb5wFPDxCtN3OmuV7PhZxP+6MtufEqshiDse8LLrThcm2+7PkGfaibjhiUwvgGSvGgdLU7mN1bO2KiJ81iOZwUlJViOuMDWkztNGmfBErpc24GMz7MzF7PLGd51XIChEaRQGQwZO70eJhV4MHsvFEEfAIfu41U1ZihTmEJBgaesKICzxnDVOXDIo7iPbpDQixGa26ZUbf8G7WK6Ne1XIfO+7Y7qs/SBCDDL3h/w+BtEl0Y9yvvQFNiW9CjLWVMqK5Bi7mTsO+7YG2o9YQd7WqaNuvx3xh6Ws65rTroi9bYGYXNSAz0nSxSJj3DVS/zLfhl8rdN8JD+sNmt90cKmCPaCqyJwe2dMtdqKTEyI/nwV4ueNn1TW7iEZbK4qxbv+9q6TxKSKvJNezS6IHnmHMMdrAqvGakddp9gg47lQN+oIS5oK0xfJVN0AUa46Vv5gIzvcPQfKHEnlru9/HRRash7xcioAGb7IR6AqBjdTJd3anSFnK1A1KqZKEsCho8vVwXXeKz9nAEpRmvA8/ynMxrwMnJhwoGFxZsointGnkeCNS8yDW6DpXfmqSlus5h2jLNMc+fGg/uio3g/WOZZkdt0r3+/iWMYG8bA+Hj+pSgN8RhAKEvMFHOte1AH9ESc+5aHLh964gkjGk1xBrPYu3Q6HpucoHlMaMr2LaRnN5j/BtX5duSG/Ool07ekhKbwbGcANr3AkZGLVl6DqBWOzY0Y/h69zdFa2VKWvqDOR3HC8QNzd6bHbyEmAsr0U7QNRJGx6mxFKJRIqmvcuUckd1EYK/stOygXCy/UmuHvsBM8PGjZL9m+Jr4M9GS4sEL/MsaqsYRCFVztFRZGQ1WHMA5vjnm8kOK6snDQAJtDcs3f8WoYFRnDvm0B+B37dnyTJ2oWY0Chc70dFecWR6rpsnktsqCrg/G8TMb4813QfHlhbKZfGCDOwnRD4BKX7HExY4EI/GnWJPjF7T48vi/NdUQRBEJnxP+ZL8JAUY/Vq0YDxz70XF/BKo+APZsM/xLTQC0H+2xOypQJv7YJJgwffcp9lH0enEsnYyoh6LB+v4eB4P7zmKKGC46Z8yITmLLLIg18Me9RSB6c7x4GQ2YMWta7UGeO5u1+uzD1XucbqCN+X+oLIsB3fuz/VZaS8K9iAdxGb6+6HxpYxRY7I+yU+qUOwc7dV9gDxip/QaPEkO2mxAKow1v6ctkfWy8uB/Ka8QdZ2brKngDsKfuIr4nA+XdVpOyFx9/Ha6aZVVrGCWl5fiwcAWoKBIFK/NOl/kEDlhk9Id4ufiewgcKaYY427ZPLYKkON1QgTs744e6ukHZAHas05fGpmOCRLMNWgRuZ09XVd+tx8cFkCMN7JHXSJWuPKl6oO+MH6h6unydJS2/mvpp9L9ALHRrLSP2RllnIny3YdROzCrl9q0prNgYq4vLeSp5CLu7PyzzKMEJ8Yh2ZGI565o8SGr6HxqCPmABB4WVLZmpCdZITPixIe9x5wSzhbTWdoasbyPngM2rvJ1/YMilpLfAdlTHteL2DrjTLkRlhJ6IEORyscnpa0S9I/5SRFAs/2rhhUz1IlBcqiNmdptyI7xFn4XVE8FqoswHlpQktTBMTdSuI38MTU0J3rEGZmM0eJOJDIWmXgk7su5fR/zQ1iu/vVhLBIM8PrgtMGlA8ePr20i/HcvlqAgd3N50gPVUOidDi1miSc5W8m7d+tFXpzWd984EaYt87DRSX3NatDPtBw4QVN61RxRcBeIkE/BcXcg2IKFMpnA1rsL1M7jwwT/aO5/5VTk/xhuP2+IGALNKk1PJW2lKbU8LTP4sQa5qgMAlNS39iiLjUPP4caiC5c9Qz0Oh5cVVxCP2T/O8nH1lImXneXjPQjCZBipC9fqn+aqB6OEuZMhUOAFMK+0dBvtO37Id/nuszI9D9a6L3eiRbQCK4t/CI+EEwy8WyI+CLZiCSSHjlp2jAUeJ/Tmt/zbxVNxCZAOQLQ8ELTXzqN6ast5q9LcI6rWMILLxh1hKSxm9tu10pK4e+tyLoOPeR3eKHFLnlmN7V6hik232NbgUd9rTX8HI0YtlpBO9EoAyVLEx8vhkiIF8iPPPP6/kMFESfxHb3MolFsZA8d8hzXzX4xAyeHYW8Erpiu85vOZajHPaFwbPfc5S+z1U9AsAsgLkbhI//Npf0Kori1YPUZ96a7w2hxFBJvF27OlLrphCtio6+tky81Oy2QOQtCwN2zUo9BfDyPwIjY8KBE0jxDevtxp7Zg+8rJFKnK6rFoKv16vz/RHJmyEbCrY+yK6slxrbHiNHBHs+5Fby947/mJq00IZVeKyeRvZGqH1O78mD1aPognfq8SXRcEAHtaiT19KWy88PmEEfV0DYdYdxufIS++lXL83YqOJRG3ZdWFZCRaqiv8oP4DqP+8VD7qnT1SvM61BVyPUgYkbfYyvGz5lJ5LNjTTberHGNmIqVbkyspb4D0yFXgr469CcDkq0tfbJI982pDdn5u6i8eMmrc7bpR2FI4JVHMny99bLNqQ8JQtZfqVvpPdLieeMO4981nM26S9lDHqgG4dSWScByP90/XqK1CgD3PpwA53AVhcoUjb3W67sNahN0vsfXclwi/CxjZLdkhrhmkVwD5359HZcDOfoK1yO1ao+DbUm301hb3aeZoriKBSdYjVHhjjlofKX9jQLns8opoMZvTZUMdFHAZikFiKMM3Nbs/VhfMPNJu535DkPLycpgf8ND+5yH2q7D4p3/Wgx+2GJ8+7pFYquzHXI7sWu+ivNgXtI8DiNFw+/MBcbnI037TIAKkB2o7SXK45On2PhQ12Wbav6tmRDWOlIzzzIaMaaKeO3KZzlVRMp9weO7hreix0nm5VttVy1ChmJM8NNC02SYOp3F6duqZ9Lpl/4VgGP10BlFU5b5tyhguibpjzwyXgK1L3VeC3vuE6hUlv3S97zXCdpSwsKEE9le5ZrtH3zPkMyVqp3HvP7IfnOydsifhcF4ZTfZOs4QlhwwVNeeD27OsJ83PDMrEOo+TZTcRgZOT7ynhdp+mllLt76c1UQyPvhk2uZcd10LNXLy9NGCijcU4IV+OeQNKGs97kzs2ZUZSzM0SthaTKWm7hgaGBznyXVal17ZeRVCPg38gFxHOT2C0crD0b9XZTo1GP0Nh1K3ixEL1GJkzkM0NCa9nR7WbLJnhPJ/XUOVmMvG0myl3UGF6otQEYzkGkB2/ntSKbMa51ETxPiMuD6FiybsavvLfbeJaQO29GmrcAIEmcUwnRQvC4neeK4Sc7oWRL/dPB1KJOGxE9NQf1HuY598ZYHoh4TW6JZK02QL8WiRLgT137UW09RyF92Uwmm+10jIS2XeS6O1x/0wImMIlG+tb9Azxb2d+MHhfe+nwRXH3eQp5wQya8Za0uFHopDaFqsfinJ4vLN/7hJZAvlR6jaDqdA0kfnNeLb7iSTZI8RL+aYTQh6qI1wZnjqiuz40Fi9G0L1LYMsAXFUiVRdFOowsiFqRBsOl0x2EvLKVCHb3ed2zgc50qz7gkaCeuzZx77a1BMCMHp3Pd+xpE9mXIUDWNhi2vD1ib5zp+3wqHm1yBOaoP5A8DstovBrjoy8gNKaa2l7hHRL65wuN3xCsIAndgOF8QdL1H3yIwiVXM/W+ubWaFIYv8UO4Lo8XVDBxckgddmdSv4MTT5qNEij300/waz4u0rl4nsAOe2sbp2OzO6iOzuD3NGOB/q8br7wiTS2aniGohfEtvvTVJeAukgiqTzaCO9TXgzWOyYlitqVOiqi/DJd6z2R/rDraU2KMxTkc0UtNFa/q7WDL/HlPyZAdp6RlFCKCVcCWTjFhvy89Zj10cZ40q1Z+uF7tjEQO1VrvhtejwWzXBNYErWVWTeMAWvOGrdHlhPUKhO6FLA5DX9sAZyGfI2ExSxHjErVkNGIZkT8Tyag0v3OyPDpoMoXxPML2AVdpyIAnegFoylK0jFeefb6zjSOY7b/78XpeS3S6tl9HJP26eYe9p9PrFsm9saM/iK2AuVDARVvy5Bub6JDxr4l4giKx0fz+4/qaJBhh49YYi243ja9VcYQbk5/XgbHc+Ms+rRgUaOdUOClQ4L+j/4h53f9TyEYzwTWv1PZqPCOYoUOg1WAkLoQ+CnUiRMNEUUcPCu45jTEhoGjFKpjblb8E6iLNZ+UxN8l8wmDWFiS7Ft1JaIBHgRukdJ7kX/aR+bExV80P7cjQUJrXsDmSfbL6w2+5+uhNWQQ9j6bSsLblAEDGZyLMe/sIgg6qyh0FsGNandK+24UVueB9MpAiBvZj7H2MwYVyr5/mvfqXQ4RLpHwueQmwSi1RlSjQ1z6yM8FLLE7htpvy2TMIGcaSCTz5wqkJeMpNeIfiKO/7pZdER4F/+5FeLZ6ydsQlSXUEvUMIgB0UuNYyrgzHpUREQsSxrmDhd7439AsK8MXq63tTQHmJzLE41dBbUIOJooKV9/mOPOo9GpqyPG6DBPl1QdK92tHwxbbDUutdS/o+2P8IO2bcbZQnoBxdqlC1Lho3Z0qFcHBwETBi3E1U+amZQ7kbCx4LP3TZWXbtVFuy525xa8kBRMpv6fBKZrwpHrHAjL9ROEXRXwISP8kck1+qGkMgmRAnyPgEwXMePNAvlEBUR296dPYj81wVyawZGJ9Bj7XjOTIaOAoL8838m7coCAmnYmAGUKqTZNKS9YLg2kVknDeVZ4SidMLFlcS3x/0ykcEgToiHExfr0UfWdeRNhNECcfVnLhbC+9Zxw8Yemec74CRUqx3qE17TmO00dwK44pevlh2RHE2f4+yMZJvgAS+JP2RiHjNtJmr711JQpbWZacrZNPXbZvexhARYevRkOHRmkopTXPwEbsSBKUbeAH/pXlD6aSgccKDOH1KlaPBgD76f7Ac9DWuT65ulMc7b1kWVoaDmsM6QncY2VxuDnbDNoEt7cNsFYwIaOsvgNlqerrQL1f6z1+JnThw8Iksn6VQyPVKEiioNjJHS5OkYYeKyu119Ns+GgEG5meVLh04oWJYPl14JT+1vctSjlFilm8ax1fruiVkh6R8QALglrZmic8QskvOXO8kWPDCBse8Z8V/L72hrt/N6UfGGthi+bMpL53klXRUXGBrZXXxeXvLshNCc3Gr+L+kaBo0LSXdn5TZ7MrLajP0uchLhwe3bGuaxNzed3Ilk1J/G4IYML8I/YdcidwyIvUrHiOsA/z2TLeJ3XDf9wLPDJiTUJVb+pfqWtQJ6MHg7Ib3X4INmRllmQc8mKgmQZiSNOM8ln97Hc5Gb5A0fyralbTNadY4MBBcmy+pYhr16McTTC7l9HpPpWz5k9WXWv6NteWTxgEfcIlJIUUSZemfW18KoWYO+cjgf8njZHlEnZAG4cL36JOwudGnDhfO94/B4ARGFB6UpbB+1u9/lSbEFc5DdP/djZ5XjBlhiPdt4mi9QmI2A/5jfzpQtcVWJtrU2u+Xam8eE4CvHMheijV2yiltjvEcJlpdlCmt7LgocOHS6xhwXMTlvyvH9DpJuhFV9kFOr/e13mK0kN1o4Q/3n0SScCXMM0K+tAlaxDIRJTkSKWil3YNiHF3qj6SGpmvKXS15Ya64NiQI+i6aQ/YvoFkXlpknhbzfpAE2HBlFgiZMqDBY0VDMrTo1NObgC4b++r8k6FfFEFlr0cLC+DqROouxna3mqIUjgHGFjd8by+qhie3ptwRe52McM151m7ELysG4+PqcJU1o8kG4UzvBSIgN9EPaSn/u1tR4a+ru1Q9GSFwxoMSgKW4AUmNgLGFGaW9IGNBga6h7RawzNKBW6rqABZU/s/mniF70UYlYFw4STscgLOo8lEZ0cekUyRcfsujELf+7NrNswg/KT8RVUcKErHlt/Yw8Fgq9t4+i47V//VqNgmBBpI/q9IBmmwBYRzuCJq8LkVsKj3iUGrZ82KuzasG4E6aoMu1h9aoz6VeEC+ky/taFkMdQPb8UogQasGJKgZSRnGeGXZ+VCbZGfsBwUFUbtRdvyM7YXWUiScqoLflJSbxVuEjROowUjc1s9nKd2H3tc3nZ5io0odGQH4noD/L2SOOuzzSdcZ0z14C0ev3SA2fvc6dPYOhfHAdRUtTdCLamrjZhMUKWATyIZO7lQt4a59avSMmnaWocNHRlnI+USzP1jgv7VJyGrU0DQFzUILR1y5AcwL6BuAYhW0IE3DEE7WLFm98kgqqBQ7A8h0Rd7aQnaWwrx+v7064DBk2uGX8McEKXFmTvQYBEPQnSK/IX4g45FfxRLdytQp2nnFvN3q3L3ftw/2ET/3V3KTq80Q37weacBC0e4Z2CU+rcInQGu/TFHjJE4EIczHkSBmm6f1yOPCPuJk1dfjl2fjB5jEAolXufX4OZFASRD4GMbt+tGeAymqLIrFnQnLCupq/6GT7dgPzqU86N0s1NL2Bhz0kw/tNA7u13fHjMUieFEA4DLeg7T2zkEz89beZ3Wgcl2tW4KxQ/iMfeU442d3N6CB5C5ZFcV+M3ojTUF/MtXcXW/mCsRfI993aR5QDMAncd0J32Az67RgUmIwiNWEk8cRyGWseK0f/pmSyUCOjpC3q0wzFhDApfFq4a2EBOCQCE1DifDtgjs2hHlsgA1Tx1HD1h2Ithy6aQXpkrTBxxpnJaiG3yw8MFBcNb87tV5lUL2IuvgdtLMjjLttbWQLCcTpHNKxrB5nKXeVSqMSfFsEr/TbjevOR6mnKRdAr3wR23LKq+CKrLwp8+Mn5SyVSzOW3J4RiOtKc7S2H+rxkrj0ClFZ/LzoFCfX9z3WdIjGK4tJucKjQW/TbWbGd0j0V9RhriV2/2P3g5oLem0meptAc/aHJ06+qZZgujmBE67esn+X1ZweQCqRJ1HEmR21C1bDDQF1iA5GC2oRQcsiUGmSabO8dWChh17yqRqTc4EGIT+SS9TffgLAjXykuLq3cjW+AMsIl6j+n7nTDXJSXGM9z4FIFvBQnWAaV57W0XtF0aBF2KlYFWLBWICe0XPHVVikQ/9bDZiIYv+1pAwR+ouZLCuPaqJQaMExPYbxLmjZkuyMi7AhcXqPPCVHAXztFlrYXwzXbxzt4/QSwFc4eDHItLrjm4caOw60PmcmemYD/wfdrNyds2snYU+gmOAKBDwzy/WzI0zbhpHoj2zv2vOrCz7AuCwYZzjuIM1xA2qqk4XWb8VkJRAdLHJLbCPCVZcqAQQlBLDBLn1givrWoxQrHMHDeuQg38BMbQab2RR+U74jfBIiL9d2EbYVszODijJ4htixpPB/EGP9ydEDLL7YfbcTQBqFi2hoKevq5Mk9U45LN5kqb/dTRoMkW/+N6KPdjpWISLUzaui/w404pT5McRT5elUkPCgqoBDvnMuLjK+T+F0QJkAao6E3dZzy7JeJC++Pm6p50rGvYwAlD9sjIgBKMjkMHqiKhbGA/VrKk4ylQ+IeAzX1U8bf6QpapwYLLpWyOhB/tBBFGWONlFpd/wr580Nyq4VomNtAz7Cg03hjUss030sqP5JmZnIEB852uyBJtvJyKGfYjlv9gy3Z/kIVZICuK0aRuu9uDEYRde+zAvRuNEv0DhAYv1pjr2W3xbr1yrKTVfIgg+KNkOrHuIlo4seu4xhWv1AzxHRz9Y3uNGqJ7rQCqd/t3aBOet+mczvqSnCV+cQuAvU+mSHK/R3a/9mQU2n6C/YH600MlVWPy/vHozTCJpkAT9t2JKcFEiKDaPXQ2cwMIv16B5ercEzaSzJmVrW0VkuYSW0dG5UvPex9InX9ndgRruxIqommyy1S8ozRGXiTVit7WPCg+ikcl2Nap00felZgH7bR4gNpsh1iY3QM6MtgYjx4vWr/e3EA8UcfmLrN2kHb2Ul9A7xOa1wfDSW0xSmeQ9ywXujzh5O6cH5efVBhQU1canychsbxvjkz1MRJzblav45PiqFa5x+GQIBURN78zkAP+QllLuUFKM9RahA98hz41yf+aZLNizUHFDtp1m9dE21LpDLdL53raJIIioaIwmIbd4KlWwk6DFqKu28WnNhtfY/z0CKpf+NP0hpuDpDuUiiDMOuCPG0ldUa/NMlVGBJ+0PsbdrTUqfjtfiboVBgttu4o0e8pNPRT5m4Ygq8WJDyk/Rq1r9ofPVpDqT4EC5Lz9njQYoRx4N2ALH2NbrYhlUlxrm0E3l9yjgFUBfOdbAu83a3gR4Jk/wq0lqi3QzIvtT12h4bk60LsCS6/NP0GxsHdZGrvZ8lnasmU2TxtEczf/qyhlu+yiHDO2IZOy9NWJWSsrWR2T8Br5G0XXKxPTIkcZi1O2S3hKTLWkX+jgoLC7Q1Of815seJWcDjd7pJqNi8CYG0G6dGha5sgv6G5Q7P9ax1cN0HAZOABef7Vsgbs0dtvAx+Kw2QvqBHAYnNT0tt9aMVyUa3QqIAZVY6ivdVDqB12CBkYa2lKejC5DEQAAgTMHrg/X8QwQa8xI5WviNqfz3qkhNnrHUeZXrhCXzrOaABSpTL7aAs6xPssUcFXnWUMuguMGHF4xEN3CP2cmvCOefMzJzDYjwN5bdeLR2um9KmdiLMi9OBC7EDpB47Wb4j40n9WNzb9fwEcQaxTNS7tChkDMfdfxkYPo2MDEnK/MD3tuEm8TI6yuygYLsNv9wBK8qxJje9lKKaOfjfFOxfgu7U8Y148lb15/MJDTYfWRu50fegsTxi/jsdYPxg/cqJqghT49ZAt1hn7AYrraePiHr4G8FwbAuWwBCYDXAAcLAQABIwMBAQVdABAAAAyBWgoBg+OrMwAA; VarID: ---
Type - Grafica - SymbolApiWidth: 0 m; SymbolScale: 1; SymbolApiHeight: 0.00205 m; SymbolApiLength: 0.00234 m; SymbolHeight: 0.00205 m; SymbolLength: 0.00234 m; SymbolWidth: 0.0008 m
Type - Vincoli - Prospetto di default: 1.8 m
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1; PowerFactor: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod.Qu47
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod.Qu47; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Altro - Famiglia: LFX_I_IguzziniMod.Qu47: LFX_I_IguzziniMod.Qu47; Famiglia e tipo: LFX_I_IguzziniMod.Qu47: LFX_I_IguzziniMod.Qu47; ID tipo: LFX_I_IguzziniMod.Qu47: LFX_I_IguzziniMod.Qu47; Tipo: LFX_I_IguzziniMod.Qu47: LFX_I_IguzziniMod.Qu47
Elettrico - Circuiti - Dati elettrici: 0 V/1-31 W
Elettrico - Illuminazione - Calcola coefficiente di utilizzo: no
Fasi - Fase di creazione: Nuova costruzione
Grafica - ID Label Visible: yes
Name (LFX_I_IguzziniMod.Qu47:LFX_I_IguzziniMod.Qu47:...) | In | Contrassegno | Livello = Livello abaco | Host | Quota altimetrica da livello (m)
8667847 | L00 - Piano Terra Piazza ELETTRICO | 4020 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 5.28
8667859 | L00 - Piano Terra Piazza ELETTRICO | 4021 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 5.28
8668112 | L00 - Piano Terra Piazza ELETTRICO | 4024 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.68485
8668129 | L00 - Piano Terra Piazza ELETTRICO | 4025 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.17576
8683073 | L00 - Piano Terra Piazza ELETTRICO | 4157 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.00606
8683410 | L00 - Piano Terra Piazza ELETTRICO | 4158 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.86
8684698 | L00 - Piano Terra Piazza ELETTRICO | 4159 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 5.395
8685685 | L00 - Piano Terra Piazza ELETTRICO | 4160 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.36364
8689700 | L00 - Piano Terra Piazza ELETTRICO | 4186 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 5.4
8689709 | L00 - Piano Terra Piazza ELETTRICO | 4187 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 5.4
8689730 | L00 - Piano Terra Piazza ELETTRICO | 4188 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.85455
8689751 | L00 - Piano Terra Piazza ELETTRICO | 4189 | Livello: L00 - Piano Terra Piazza ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.34545
8694955 | L00 - Piano Terra Piazza ELETTRICO | 4407 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.78
8694965 | L00 - Piano Terra Piazza ELETTRICO | 4408 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.78
8695951 | L00 - Piano Terra Piazza ELETTRICO | 4411 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.23
8695968 | L00 - Piano Terra Piazza ELETTRICO | 4412 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.01
8697931 | L00 - Piano Terra Piazza ELETTRICO | 4497 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 1.5
8697964 | L00 - Piano Terra Piazza ELETTRICO | 4498 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.9
8697973 | L00 - Piano Terra Piazza ELETTRICO | 4499 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 4.9
8698391 | L00 - Piano Terra Piazza ELETTRICO | 4503 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
8698400 | L00 - Piano Terra Piazza ELETTRICO | 4504 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
8698417 | L00 - Piano Terra Piazza ELETTRICO | 4505 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
8698426 | L00 - Piano Terra Piazza ELETTRICO | 4506 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 4.69
8700337 | L00 - Piano Terra Piazza ELETTRICO | 4585 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
8700346 | L00 - Piano Terra Piazza ELETTRICO | 4586 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
8700355 | L00 - Piano Terra Piazza ELETTRICO | 4587 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
8700364 | L00 - Piano Terra Piazza ELETTRICO | 4588 | Livello: L01 - Piano Primo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.9
8706900 | L02 - Piano Secondo ELETTRICO | 4830 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.855
8706909 | L02 - Piano Secondo ELETTRICO | 4831 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 1.855
8706934 | L02 - Piano Secondo ELETTRICO | 4832 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.784
8706943 | L02 - Piano Secondo ELETTRICO | 4833 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.784
8708016 | L02 - Piano Secondo ELETTRICO | 4869 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3.94
8708042 | L02 - Piano Secondo ELETTRICO | 4871 | Livello: L02 - Piano Secondo ELETTRICO | <non associato> | 3.94
8708051 | L02 - Piano Secondo ELETTRICO | 4872 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
8892804 | B01 - Piano Interrato ELETTRICO | 5034 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
8893389 | B01 - Piano Interrato ELETTRICO | 5035 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
8893399 | B01 - Piano Interrato ELETTRICO | 5036 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
9438613 | L02 - Piano Secondo ELETTRICO | 5117 | Livello: L02 - Piano Secondo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.94
9446669 | B01 - Piano Interrato ELETTRICO | 5257 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.42
9446845 | B01 - Piano Interrato ELETTRICO | 5259 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
9446867 | B01 - Piano Interrato ELETTRICO | 5260 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
9446899 | B01 - Piano Interrato ELETTRICO | 5261 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
9446918 | B01 - Piano Interrato ELETTRICO | 5262 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 3.3
9446962 | B01 - Piano Interrato ELETTRICO | 5263 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 3.3
9447100 | B01 - Piano Interrato ELETTRICO | 5264 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9447174 | B01 - Piano Interrato ELETTRICO | 5265 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9447198 | B01 - Piano Interrato ELETTRICO | 5266 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9447215 | B01 - Piano Interrato ELETTRICO | 5267 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9447230 | B01 - Piano Interrato ELETTRICO | 5268 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.6
9447510 | B01 - Piano Interrato ELETTRICO | 5270 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9447553 | B01 - Piano Interrato ELETTRICO | 5271 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.5
9447567 | B01 - Piano Interrato ELETTRICO | 5272 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.5
9454247 | L00 - Piano Terra Piazza ELETTRICO | 5334 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 5.395
9454268 | L00 - Piano Terra Piazza ELETTRICO | 5335 | Livello: L00 - Piano Terra Piazza ELETTRICO | <non associato> | 5.395
9455822 | B01 - Piano Interrato ELETTRICO | 5393 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 3.42
9485421 | L03 - Piano Terzo ELETTRICO | 5418 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.324
9485462 | L03 - Piano Terzo ELETTRICO | 5419 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.324
9485482 | L03 - Piano Terzo ELETTRICO | 5420 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.324
9485485 | L03 - Piano Terzo ELETTRICO | 5421 | Livello: L03 - Piano Terzo ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_AR_M3_0_00_WPZZ_001_R01.rvt | 2.324
9607102 | B01 - Piano Interrato ELETTRICO | 6075 | Livello: B01 - Piano Interrato ELETTRICO | Modello di Revit collegato : Tk25838_UBO_PD_ST_M3_0_00_WPZZ_001_R01.rvt | 2.5
9607103 | B01 - Piano Interrato ELETTRICO | 6076 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.5
9607104 | B01 - Piano Interrato ELETTRICO | 6077 | Livello: B01 - Piano Interrato ELETTRICO | <non associato> | 2.5

# IfcLightFixture: LFX_I_IguzziniMod.R664:LFX_I_IguzziniMod.R664 (136)
Type - Material: Alluminio (1)
Type - Altro - Categoria: Apparecchi per illuminazione; Nome famiglia: LFX_I_IguzziniMod.R664
Type - Dati identità - Descrizione: Fixed round recessed luminaire ø59 Frame - LED - flood; Modello: P318; Nome del tipo: LFX_I_IguzziniMod.R664; Numero OmniClass: 23.80.70.11; Produttore: iGuzzini; Titolo OmniClass: Luminaries for Internal Lighting; URL: https://www.iguzzini.com/laser-fixed-round/
Type - Elettrico - Commenti sul wattaggio: 1; Lampada: LED
Type - Fotometrica - Angolo inclinazione: 0 deg; Colore iniziale: 0; Definizione sorgente d'illuminazione (famiglia): Punto+Diagramma fotometrico; Efficacia: 77 s3*lm/kg/m2; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; File diagramma fotometrico: P318_A21H.IES; Filtro dei colori: 16777215; Flusso luminoso: 577.5 lm; Illuminanza: 4.94666 lx; Intensità iniziale: 0; Intensità luminosa: 45.956 cd; Temperatura colore iniziale: 3000 K; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Watt: 7.5 W
Type - Vincoli - Prospetto di default: 0 m
Type - Pset_EnvironmentalImpactIndicators - Reference: LFX_I_IguzziniMod.R664
Type - Pset_LightFixtureTypeCommon - Reference: LFX_I_IguzziniMod.R664; TotalWattage: 1 W
Type - Pset_ManufacturerTypeInformation - Manufacturer: iGuzzini
Material: Alluminio (1), iGuzzini Vetro emittente, Plastica, Nero opaco, Laminato, Bianco
Altro - Famiglia: LFX_I_IguzziniMod.R664: LFX_I_IguzziniMod.R664; Famiglia e tipo: LFX_I_IguzziniMod.R664: LFX_I_IguzziniMod.R664; ID tipo: LFX_I_IguzziniMod.R664: LFX_I_IguzziniMod.R664; Tipo: LFX_I_IguzziniMod.R664: LFX_I_IguzziniMod.R664
Dimensioni - Volume: 0.000074914 m3
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Sposta con l'oggetto più vicino: no
Name (LFX_I_IguzziniMod.R664:LFX_I_IguzziniMod.R664:...) | In | Id host | Contrassegno | Livello
8697025 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4448 | Livello: L01 - Piano Primo ELETTRICO
8697027 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4449 | Livello: L01 - Piano Primo ELETTRICO
8697127 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4460 | Livello: L01 - Piano Primo ELETTRICO
8697142 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4461 | Livello: L01 - Piano Primo ELETTRICO
8697174 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4462 | Livello: L01 - Piano Primo ELETTRICO
8697189 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4463 | Livello: L01 - Piano Primo ELETTRICO
8697212 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4464 | Livello: L01 - Piano Primo ELETTRICO
8697229 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4465 | Livello: L01 - Piano Primo ELETTRICO
8697244 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4466 | Livello: L01 - Piano Primo ELETTRICO
8697261 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4467 | Livello: L01 - Piano Primo ELETTRICO
8697288 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4468 | Livello: L01 - Piano Primo ELETTRICO
8697305 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4469 | Livello: L01 - Piano Primo ELETTRICO
8697322 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4470 | Livello: L01 - Piano Primo ELETTRICO
8697352 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4471 | Livello: L01 - Piano Primo ELETTRICO
8697367 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4472 | Livello: L01 - Piano Primo ELETTRICO
8697382 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4473 | Livello: L01 - Piano Primo ELETTRICO
8697401 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 4474 | Livello: L01 - Piano Primo ELETTRICO
9444131 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 5246 | Livello: L01 - Piano Primo ELETTRICO
9444151 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 5247 | Livello: L01 - Piano Primo ELETTRICO
9444171 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 5248 | Livello: L01 - Piano Primo ELETTRICO
9444199 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto | 5249 | Livello: L01 - Piano Primo ELETTRICO
9745838 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6218 | Livello: L01 - Piano Primo ELETTRICO
9745841 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6219 | Livello: L01 - Piano Primo ELETTRICO
9745843 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6220 | Livello: L01 - Piano Primo ELETTRICO
9745845 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6221 | Livello: L01 - Piano Primo ELETTRICO
9745847 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6222 | Livello: L01 - Piano Primo ELETTRICO
9745849 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6223 | Livello: L01 - Piano Primo ELETTRICO
9745851 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6224 | Livello: L01 - Piano Primo ELETTRICO
9745853 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6225 | Livello: L01 - Piano Primo ELETTRICO
9745855 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6226 | Livello: L01 - Piano Primo ELETTRICO
9745857 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6227 | Livello: L01 - Piano Primo ELETTRICO
9745859 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6228 | Livello: L01 - Piano Primo ELETTRICO
9745880 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6229 | Livello: L01 - Piano Primo ELETTRICO
9745895 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6230 | Livello: L01 - Piano Primo ELETTRICO
9745910 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6231 | Livello: L01 - Piano Primo ELETTRICO
9745925 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6232 | Livello: L01 - Piano Primo ELETTRICO
9745946 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6233 | Livello: L01 - Piano Primo ELETTRICO
9745947 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6234 | Livello: L01 - Piano Primo ELETTRICO
9745948 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6235 | Livello: L01 - Piano Primo ELETTRICO
9745949 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6236 | Livello: L01 - Piano Primo ELETTRICO
9745950 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: CLN_I_LastraContinua | 6237 | Livello: L01 - Piano Primo ELETTRICO
9745987 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6239 | Livello: L01 - Piano Primo ELETTRICO
9746004 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6240 | Livello: L01 - Piano Primo ELETTRICO
9746019 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6241 | Livello: L01 - Piano Primo ELETTRICO
9746038 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6242 | Livello: L01 - Piano Primo ELETTRICO
9746069 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6243 | Livello: L01 - Piano Primo ELETTRICO
9746084 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6244 | Livello: L01 - Piano Primo ELETTRICO
9746103 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6245 | Livello: L01 - Piano Primo ELETTRICO
9746118 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6246 | Livello: L01 - Piano Primo ELETTRICO
9746133 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6247 | Livello: L01 - Piano Primo ELETTRICO
9746148 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6248 | Livello: L01 - Piano Primo ELETTRICO
9746163 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6249 | Livello: L01 - Piano Primo ELETTRICO
9746178 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6250 | Livello: L01 - Piano Primo ELETTRICO
9746423 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6251 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746460 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6252 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746476 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6253 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746523 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6255 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746539 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6256 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746566 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6257 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746567 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6258 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746568 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6259 | Livello: L00 - Piano Terra Piazza ELETTRICO
9746569 | L00 - Piano Terra Piazza ELETTRICO | Controsoffitto composto: Controsoffitto Quadrotti 60x60 fissaggio a vista | 6260 | Livello: L00 - Piano Terra Piazza ELETTRICO
